* NGSPICE file created from vahid6i.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_1 abstract view
.subckt sky130_fd_sc_hd__ebufn_1 A TE_B VGND VNB VPB VPWR Z
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_4 abstract view
.subckt sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlxtp_1 abstract view
.subckt sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_2 abstract view
.subckt sky130_fd_sc_hd__ebufn_2 A TE_B VGND VNB VPB VPWR Z
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_2 abstract view
.subckt sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_4 abstract view
.subckt sky130_fd_sc_hd__and4b_4 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

.subckt vahid6i D_R_data[0] D_R_data[10] D_R_data[11] D_R_data[12] D_R_data[13] D_R_data[14]
+ D_R_data[15] D_R_data[1] D_R_data[2] D_R_data[3] D_R_data[4] D_R_data[5] D_R_data[6]
+ D_R_data[7] D_R_data[8] D_R_data[9] D_W_data[0] D_W_data[10] D_W_data[11] D_W_data[12]
+ D_W_data[13] D_W_data[14] D_W_data[15] D_W_data[1] D_W_data[2] D_W_data[3] D_W_data[4]
+ D_W_data[5] D_W_data[6] D_W_data[7] D_W_data[8] D_W_data[9] D_addr[0] D_addr[1]
+ D_addr[2] D_addr[3] D_addr[4] D_addr[5] D_addr[6] D_addr[7] D_rd D_wr I_addr[0]
+ I_addr[10] I_addr[11] I_addr[12] I_addr[13] I_addr[14] I_addr[15] I_addr[1] I_addr[2]
+ I_addr[3] I_addr[4] I_addr[5] I_addr[6] I_addr[7] I_addr[8] I_addr[9] I_data[0]
+ I_data[10] I_data[11] I_data[12] I_data[13] I_data[14] I_data[15] I_data[1] I_data[2]
+ I_data[3] I_data[4] I_data[5] I_data[6] I_data[7] I_data[8] I_data[9] I_rd VGND
+ VPWR clock led_clock leds[0] leds[1] leds[2] leds[3] reset
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3155_ net117 _0077_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_3086_ net120 _0044_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2106_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__clkbuf_2
X_2037_ net50 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__clkbuf_2
X_2939_ _1273_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_77_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_486 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2724_ _1127_ _1115_ _1129_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__o22a_1
X_2655_ po_0.regf_0.rf\[10\]\[10\] _0982_ _1080_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__mux2_1
X_1606_ po_0.regf_0.rf\[8\]\[0\] po_0.regf_0.rf\[9\]\[0\] po_0.regf_0.rf\[10\]\[0\]
+ po_0.regf_0.rf\[11\]\[0\] _1407_ _1409_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__mux4_1
X_2586_ po_0.regf_0.rf\[12\]\[11\] _0984_ _1041_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__mux2_1
Xfanout105 net108 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
Xfanout127 net129 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout138 net145 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_2
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlymetal6s2s_1
X_1537_ _1356_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__clkbuf_1
Xfanout149 net151 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlymetal6s2s_1
X_3207_ net117 _0129_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3138_ net160 _0008_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__dfxtp_2
XFILLER_27_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3069_ net141 _0027_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_42_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_383 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2440_ _0708_ _0709_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__and3_2
X_2371_ _0921_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2707_ net97 VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2638_ po_0.regf_0.rf\[10\]\[2\] _0965_ _1073_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__mux2_1
X_2569_ po_0.regf_0.rf\[12\]\[3\] _0967_ _1034_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__mux2_1
XFILLER_59_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1940_ po_0.regf_0.rf\[8\]\[14\] po_0.regf_0.rf\[9\]\[14\] po_0.regf_0.rf\[10\]\[14\]
+ po_0.regf_0.rf\[11\]\[14\] _0474_ _0475_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__mux4_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1871_ _0418_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__and2b_1
XFILLER_6_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2423_ _0950_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
X_2354_ _0911_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_2285_ net7 VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__inv_2
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2070_ _0666_ _0671_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2972_ _1291_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
X_1923_ _0473_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__and2b_1
X_1854_ po_0.regf_0.rf\[0\]\[4\] po_0.regf_0.rf\[1\]\[4\] po_0.regf_0.rf\[2\]\[4\]
+ po_0.regf_0.rf\[3\]\[4\] _0433_ _0434_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__mux4_1
X_1785_ _0419_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__clkbuf_4
X_2406_ _0941_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
X_3386_ net109 _0304_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2337_ _0902_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_2268_ _0851_ _0853_ _0682_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__a21o_1
XFILLER_37_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2199_ po_0.regf_0.rf\[7\]\[7\] _0791_ _0781_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__mux2_1
XFILLER_25_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_5 po_0.regf_0._5_\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1570_ net80 net99 VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__nand2_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3240_ net150 _0162_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3171_ net122 _0093_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2122_ _0699_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__clkbuf_2
X_2053_ _0648_ _0654_ _0649_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__o21ai_1
XFILLER_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2955_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__clkbuf_4
X_1906_ po_0.regf_0.rf\[0\]\[10\] po_0.regf_0.rf\[1\]\[10\] po_0.regf_0.rf\[2\]\[10\]
+ po_0.regf_0.rf\[3\]\[10\] _0420_ _0422_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__mux4_1
X_2886_ po_0.regf_0.rf\[3\]\[0\] _0705_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__mux2_1
X_1837_ po_0.regf_0.rf\[4\]\[3\] po_0.regf_0.rf\[5\]\[3\] po_0.regf_0.rf\[6\]\[3\]
+ po_0.regf_0.rf\[7\]\[3\] _0425_ _0426_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__mux4_1
X_1768_ _0403_ _1445_ _1486_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a21bo_1
X_1699_ _0005_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__buf_2
X_3438_ po_0.alu_0._10_\[13\] _1504_ VGND VGND VPWR VPWR po_0.alu_0._11_\[13\] sky130_fd_sc_hd__ebufn_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3369_ net109 _0287_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput42 net42 VGND VGND VPWR VPWR D_W_data[1] sky130_fd_sc_hd__buf_2
Xoutput75 net95 VGND VGND VPWR VPWR I_addr[8] sky130_fd_sc_hd__buf_2
Xoutput53 net53 VGND VGND VPWR VPWR D_addr[2] sky130_fd_sc_hd__buf_2
Xoutput64 net64 VGND VGND VPWR VPWR I_addr[12] sky130_fd_sc_hd__buf_2
XFILLER_36_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2740_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__nand2_1
X_2671_ _0722_ net24 _1092_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__mux2_1
XFILLER_12_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1622_ _1414_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__buf_2
X_1553_ _1364_ _1365_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__and2_1
X_3223_ net117 _0145_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3154_ net109 _0076_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3085_ net141 _0043_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2105_ po_0.muxf_0.rf_w_data\[0\] _0694_ _0697_ net1 _0704_ VGND VGND VPWR VPWR _0705_
+ sky130_fd_sc_hd__a221o_4
X_2036_ _0641_ _0643_ VGND VGND VPWR VPWR po_0.alu_0._10_\[8\] sky130_fd_sc_hd__xor2_1
XFILLER_22_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_270 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2938_ po_0.regf_0.rf\[2\]\[8\] _0803_ _1270_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux2_1
X_2869_ _1235_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_77_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2723_ _1127_ _1115_ _1113_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a21boi_1
X_2654_ _1084_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
X_2585_ _1046_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
X_1605_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__clkbuf_4
X_1536_ _1349_ _1351_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__or2b_1
Xfanout128 net129 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_1
Xfanout106 net108 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout117 net119 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_2
Xfanout139 net141 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_2
X_3206_ net147 _0128_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3137_ net115 _0063_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3068_ net139 _0026_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_42_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2019_ _0624_ _0625_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nor2_2
XFILLER_2_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_395 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2370_ po_0.regf_0.rf\[9\]\[1\] _0725_ _0919_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__mux2_1
XFILLER_49_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2706_ _1112_ _1113_ _1091_ uc_0._01_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__nor4b_1
X_2637_ _1075_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2568_ _1037_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
X_2499_ _0999_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
X_1519_ _1345_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__clkbuf_1
XFILLER_67_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1870_ po_0.regf_0.rf\[8\]\[6\] po_0.regf_0.rf\[9\]\[6\] po_0.regf_0.rf\[10\]\[6\]
+ po_0.regf_0.rf\[11\]\[6\] _0420_ _0422_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__mux4_1
X_2422_ po_0.regf_0.rf\[1\]\[8\] _0804_ _0947_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__mux2_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2353_ po_0.regf_0.rf\[6\]\[10\] _0822_ _0906_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
XFILLER_84_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2284_ po_0.muxf_0.s1 po_0.muxf_0.s0 VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__or2b_2
XFILLER_84_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1999_ _0598_ _0599_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__nor2_1
XFILLER_4_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_83 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2971_ _0791_ po_0.regf_0.rf\[0\]\[7\] _1289_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__mux2_1
X_1922_ po_0.regf_0.rf\[0\]\[12\] po_0.regf_0.rf\[1\]\[12\] po_0.regf_0.rf\[2\]\[12\]
+ po_0.regf_0.rf\[3\]\[12\] _0474_ _0475_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__mux4_1
X_1853_ _0414_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkbuf_2
X_1784_ _0000_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__buf_2
XFILLER_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2405_ po_0.regf_0.rf\[1\]\[0\] _0706_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__mux2_1
X_3385_ net110 _0303_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2336_ po_0.regf_0.rf\[6\]\[2\] _0739_ _0899_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__mux2_1
X_2267_ net83 po_0._1_\[13\] _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2198_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__clkbuf_2
XFILLER_37_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_55 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_6 net26 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3170_ net120 _0092_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2121_ _0715_ _0716_ _0717_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a31o_1
X_2052_ _0655_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__nor2_2
XFILLER_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2954_ _0711_ _0707_ _0937_ _1032_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__or4bb_4
X_1905_ _0529_ _0481_ _0482_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a21o_1
X_2885_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__buf_2
XFILLER_30_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1836_ _0467_ _0458_ _0430_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__a21o_1
X_1767_ po_0.regf_0.rf\[12\]\[15\] po_0.regf_0.rf\[13\]\[15\] po_0.regf_0.rf\[14\]\[15\]
+ po_0.regf_0.rf\[15\]\[15\] _1432_ _1433_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux4_1
X_1698_ _0004_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_4
X_3437_ po_0.alu_0._10_\[12\] _1503_ VGND VGND VPWR VPWR po_0.alu_0._11_\[12\] sky130_fd_sc_hd__ebufn_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3368_ net123 _0286_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2319_ po_0.regf_0.rf\[5\]\[11\] _0830_ _0886_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__mux2_1
XFILLER_66_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3299_ net179 _0217_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
XFILLER_72_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput43 net87 VGND VGND VPWR VPWR D_W_data[2] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR I_addr[9] sky130_fd_sc_hd__buf_2
Xoutput65 net65 VGND VGND VPWR VPWR I_addr[13] sky130_fd_sc_hd__buf_2
Xoutput54 net54 VGND VGND VPWR VPWR D_addr[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_460 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2670_ _1093_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
X_1621_ _1412_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__clkbuf_4
X_1552_ po_0._1_\[0\] net35 VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__nand2_1
X_3222_ net147 _0144_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3153_ net128 _0075_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2104_ _1363_ _0698_ _1337_ _0699_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__o311a_1
X_3084_ net139 _0042_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2035_ _0642_ po_0._1_\[7\] _0636_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__o21ai_4
XFILLER_54_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_282 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2937_ _1272_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2868_ po_0.regf_0.rf\[8\]\[8\] _0803_ _1232_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__mux2_1
X_2799_ net75 _1191_ _1196_ _1120_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__a221oi_2
X_1819_ po_0.regf_0.rf\[8\]\[2\] po_0.regf_0.rf\[9\]\[2\] po_0.regf_0.rf\[10\]\[2\]
+ po_0.regf_0.rf\[11\]\[2\] _0450_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__mux4_1
XFILLER_77_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2722_ uc_0._01_ uc_0._00_ _1113_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__nor3_1
XFILLER_8_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2653_ po_0.regf_0.rf\[10\]\[9\] _0980_ _1080_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
X_2584_ po_0.regf_0.rf\[12\]\[10\] _0982_ _1041_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__mux2_1
X_1604_ _0005_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__clkbuf_2
X_1535_ _1355_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__clkbuf_1
Xfanout107 net108 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_1
Xfanout129 net132 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_2
Xfanout118 net119 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
X_3205_ net100 _0127_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3136_ net105 _0062_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3067_ net121 _0025_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2018_ _0624_ _0625_ _0626_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_35_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_466 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_260 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2705_ uc_0._02_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__clkbuf_2
X_2636_ po_0.regf_0.rf\[10\]\[1\] _0963_ _1073_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__mux2_1
X_2567_ po_0.regf_0.rf\[12\]\[2\] _0965_ _1034_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__mux2_1
X_2498_ po_0.regf_0.rf\[14\]\[3\] _0967_ _0995_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__mux2_1
X_1518_ _1338_ _1342_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__or2b_1
XFILLER_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3119_ po_0.regf_0._3_\[13\] net88 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dlxtp_1
XFILLER_11_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2421_ _0949_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_2352_ _0910_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2283_ _0865_ _0716_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nand3_1
XFILLER_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_222 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1998_ _0607_ _0608_ _0609_ _0600_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a2bb2oi_2
X_2619_ _1065_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_166 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2970_ _1290_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1921_ _0543_ _0484_ _0416_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21o_1
X_1852_ _0480_ _0481_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__a21o_1
X_1783_ _0414_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__clkbuf_2
X_2404_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__buf_2
X_3384_ net122 _0302_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2335_ _0901_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2266_ net83 po_0._1_\[13\] po_0._1_\[12\] _0666_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__o211a_1
X_2197_ _0580_ _0694_ _0697_ net14 _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a221o_2
XFILLER_65_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_7 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2120_ _0698_ po_0.alu_0._11_\[1\] _0718_ _1370_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__a22o_1
X_2051_ net37 po_0._1_\[11\] VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__and2_1
XFILLER_66_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2953_ _1280_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1904_ po_0.regf_0.rf\[12\]\[10\] po_0.regf_0.rf\[13\]\[10\] po_0.regf_0.rf\[14\]\[10\]
+ po_0.regf_0.rf\[15\]\[10\] _0478_ _0479_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux4_1
X_2884_ _0708_ _0709_ _0875_ _0938_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__and4_4
X_1835_ po_0.regf_0.rf\[12\]\[3\] po_0.regf_0.rf\[13\]\[3\] po_0.regf_0.rf\[14\]\[3\]
+ po_0.regf_0.rf\[15\]\[3\] _0454_ _0455_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__mux4_1
X_1766_ _1474_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__and2b_1
X_1697_ _1487_ _1489_ _1430_ _0341_ VGND VGND VPWR VPWR po_0.regf_0._5_\[6\] sky130_fd_sc_hd__o22a_1
X_3436_ po_0.alu_0._10_\[11\] _1502_ VGND VGND VPWR VPWR po_0.alu_0._11_\[11\] sky130_fd_sc_hd__ebufn_2
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3367_ net119 _0285_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2318_ _0891_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3298_ net165 _0216_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfxtp_1
X_2249_ _0670_ _0835_ _0701_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__o211a_1
XFILLER_82_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput66 net66 VGND VGND VPWR VPWR I_addr[14] sky130_fd_sc_hd__clkbuf_4
Xoutput44 net44 VGND VGND VPWR VPWR D_W_data[3] sky130_fd_sc_hd__buf_2
Xoutput55 net55 VGND VGND VPWR VPWR D_addr[4] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR I_rd sky130_fd_sc_hd__clkbuf_4
XFILLER_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1620_ _1420_ _1423_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__and2b_1
X_1551_ po_0._1_\[0\] _1363_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__or2_1
X_3221_ net100 _0143_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3152_ net131 _0074_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2103_ _1340_ po_0.alu_0._11_\[0\] _0700_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__a211o_1
X_3083_ net121 _0041_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2034_ _0632_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__inv_2
XFILLER_50_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2936_ po_0.regf_0.rf\[2\]\[7\] _0790_ _1270_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__mux2_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2867_ _1234_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_1818_ _0411_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__buf_2
X_2798_ net95 _1191_ _1186_ _1187_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__o211a_1
X_1749_ po_0.regf_0.rf\[12\]\[13\] po_0.regf_0.rf\[13\]\[13\] po_0.regf_0.rf\[14\]\[13\]
+ po_0.regf_0.rf\[15\]\[13\] _1446_ _1447_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux4_1
X_3419_ net182 _0337_ VGND VGND VPWR VPWR uc_0._01_ sky130_fd_sc_hd__dfxtp_1
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2721_ uc_0._01_ _1112_ _1113_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__or3_1
XFILLER_8_162 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2652_ _1083_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2583_ _1045_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
X_1603_ _1406_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__clkbuf_4
X_1534_ _1349_ _1351_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__or2b_1
Xfanout108 net111 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout119 net125 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_2
X_3204_ net113 _0126_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3135_ net122 _0061_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_3066_ net131 _0024_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2017_ _0617_ _0618_ _0615_ _0610_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__o22ai_2
XFILLER_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2919_ _0937_ _0897_ _0938_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__and3_4
XFILLER_5_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2704_ uc_0._00_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__clkbuf_2
X_2635_ _1074_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
X_2566_ _1036_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
X_1517_ _1344_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__clkbuf_1
X_2497_ _0998_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
X_3118_ po_0.regf_0._3_\[12\] net89 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dlxtp_1
XFILLER_82_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3049_ net58 _0580_ _1323_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__mux2_1
XFILLER_23_231 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout90 po_0.regf_0.rp_rd VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_2
X_2420_ po_0.regf_0.rf\[1\]\[7\] _0791_ _0947_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__mux2_1
X_2351_ po_0.regf_0.rf\[6\]\[9\] _0812_ _0906_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__mux2_1
X_2282_ _0680_ _0866_ _0863_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1997_ po_0._1_\[3\] net86 VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__or2b_1
XFILLER_69_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2618_ po_0.regf_0.rf\[11\]\[9\] _0980_ _1061_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
X_2549_ _1026_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_223 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1920_ po_0.regf_0.rf\[4\]\[12\] po_0.regf_0.rf\[5\]\[12\] po_0.regf_0.rf\[6\]\[12\]
+ po_0.regf_0.rf\[7\]\[12\] _0450_ _0451_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__mux4_1
XFILLER_42_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1851_ _0429_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__clkbuf_2
X_1782_ _0413_ _0415_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a21o_1
X_3383_ net120 _0301_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2403_ _0937_ _0876_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__and3_4
X_2334_ po_0.regf_0.rf\[6\]\[1\] _0725_ _0899_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__mux2_1
X_2265_ _0835_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nand2_1
XFILLER_57_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2196_ _0732_ _0785_ _0786_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__o31a_1
XFILLER_1_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_8 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2050_ net37 po_0._1_\[11\] VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__nor2_1
XFILLER_66_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2952_ po_0.regf_0.rf\[2\]\[15\] _0871_ _1262_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__mux2_1
X_1903_ _0448_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__and2b_1
X_2883_ _1242_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
X_1834_ _0432_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and2b_1
X_1765_ po_0.regf_0.rf\[8\]\[15\] po_0.regf_0.rf\[9\]\[15\] po_0.regf_0.rf\[10\]\[15\]
+ po_0.regf_0.rf\[11\]\[15\] _1475_ _1476_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__mux4_1
X_1696_ _1490_ _0340_ _1474_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__mux2_1
X_3435_ po_0.alu_0._10_\[10\] _1501_ VGND VGND VPWR VPWR po_0.alu_0._11_\[10\] sky130_fd_sc_hd__ebufn_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3366_ net143 _0284_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3297_ net165 _0215_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfxtp_2
X_2317_ po_0.regf_0.rf\[5\]\[10\] _0822_ _0886_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2248_ _0835_ _0670_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nand2_1
XFILLER_57_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2179_ _0618_ _0629_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or3_1
XFILLER_65_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_78 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput56 net56 VGND VGND VPWR VPWR D_addr[5] sky130_fd_sc_hd__buf_2
Xoutput45 net85 VGND VGND VPWR VPWR D_W_data[4] sky130_fd_sc_hd__buf_2
Xoutput67 net67 VGND VGND VPWR VPWR I_addr[15] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR led_clock sky130_fd_sc_hd__clkbuf_4
XFILLER_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1550_ net35 VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3220_ net113 _0142_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3151_ net110 _0073_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2102_ _1364_ _1365_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__and3_1
X_3082_ net136 _0040_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2033_ _0639_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__nand2_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2935_ _1271_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2866_ po_0.regf_0.rf\[8\]\[7\] _0790_ _1232_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__mux2_1
X_1817_ _0409_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_4
X_2797_ net76 net95 VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__nand2_1
X_1748_ _0380_ _0382_ _0384_ _0386_ VGND VGND VPWR VPWR po_0.regf_0._5_\[12\] sky130_fd_sc_hd__o22a_1
X_1679_ _1474_ _1477_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__and2b_1
X_3418_ net182 _0336_ VGND VGND VPWR VPWR uc_0._02_ sky130_fd_sc_hd__dfxtp_1
X_3349_ net142 _0267_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_314 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_410 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_218 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2720_ net96 VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__clkbuf_2
XFILLER_8_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2651_ po_0.regf_0.rf\[10\]\[8\] _0978_ _1080_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__mux2_1
XFILLER_8_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1602_ _0004_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__buf_2
X_2582_ po_0.regf_0.rf\[12\]\[9\] _0980_ _1041_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__mux2_1
XFILLER_59_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1533_ _1354_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__clkbuf_1
Xfanout109 net111 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_2
X_3203_ net113 _0125_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3134_ net120 _0060_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3065_ net130 _0023_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2016_ po_0._1_\[5\] _0616_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__or2b_1
XFILLER_50_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2918_ _1261_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
X_2849_ _0877_ _0707_ _0874_ _1032_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__and4b_2
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_32 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2703_ uc_0._02_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__clkbuf_2
X_2634_ po_0.regf_0.rf\[10\]\[0\] _0958_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__mux2_1
X_2565_ po_0.regf_0.rf\[12\]\[1\] _0963_ _1034_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__mux2_1
X_1516_ _1338_ _1342_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__or2b_1
X_2496_ po_0.regf_0.rf\[14\]\[2\] _0965_ _0995_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__mux2_1
XFILLER_67_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3117_ po_0.regf_0._3_\[11\] net89 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dlxtp_1
XFILLER_82_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3048_ _1331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_243 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout91 net92 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_80_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2350_ _0909_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2281_ _0851_ _0853_ _0682_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1996_ net85 po_0._1_\[4\] VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nor2_2
XFILLER_60_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2617_ _1064_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
X_2548_ po_0.regf_0.rf\[13\]\[10\] _0982_ _1021_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__mux2_1
X_2479_ po_0.regf_0.rf\[15\]\[12\] _0986_ _0960_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__mux2_1
XFILLER_83_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_482 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1850_ _0414_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__buf_2
X_1781_ _0003_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__buf_2
X_3382_ net143 _0300_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2402_ po_0.regf_0.w_addr\[2\] po_0.regf_0.w_addr\[3\] VGND VGND VPWR VPWR _0938_
+ sky130_fd_sc_hd__nor2_1
X_2333_ _0900_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2264_ _0669_ _0672_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nor2_1
XFILLER_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2195_ _0632_ _1339_ _1336_ _0787_ _0699_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__o311a_1
XFILLER_25_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1979_ _1370_ _0587_ _0589_ _0590_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__o2111ai_1
XFILLER_0_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_67 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_124 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_9 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2951_ _1279_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
XFILLER_15_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1902_ po_0.regf_0.rf\[8\]\[10\] po_0.regf_0.rf\[9\]\[10\] po_0.regf_0.rf\[10\]\[10\]
+ po_0.regf_0.rf\[11\]\[10\] _0442_ _0443_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__mux4_1
X_2882_ po_0.regf_0.rf\[8\]\[15\] _0871_ _1224_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__mux2_1
XFILLER_30_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1833_ po_0.regf_0.rf\[8\]\[3\] po_0.regf_0.rf\[9\]\[3\] po_0.regf_0.rf\[10\]\[3\]
+ po_0.regf_0.rf\[11\]\[3\] _0450_ _0451_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__mux4_1
X_1764_ _0395_ _0397_ _1430_ _0400_ VGND VGND VPWR VPWR po_0.regf_0._5_\[14\] sky130_fd_sc_hd__o22a_1
X_1695_ po_0.regf_0.rf\[4\]\[6\] po_0.regf_0.rf\[5\]\[6\] po_0.regf_0.rf\[6\]\[6\]
+ po_0.regf_0.rf\[7\]\[6\] _0338_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__mux4_1
X_3434_ po_0.alu_0._10_\[9\] _1500_ VGND VGND VPWR VPWR po_0.alu_0._11_\[9\] sky130_fd_sc_hd__ebufn_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3365_ net142 _0283_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2316_ _0890_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
X_3296_ net165 _0214_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_2
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2247_ _0832_ _0798_ _0655_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2178_ _0616_ po_0._1_\[5\] _0607_ _0755_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__o22a_1
XFILLER_53_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput35 net35 VGND VGND VPWR VPWR D_W_data[0] sky130_fd_sc_hd__buf_2
Xoutput46 net46 VGND VGND VPWR VPWR D_W_data[5] sky130_fd_sc_hd__clkbuf_4
Xoutput57 net57 VGND VGND VPWR VPWR D_addr[6] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR leds[0] sky130_fd_sc_hd__clkbuf_4
Xoutput68 net96 VGND VGND VPWR VPWR I_addr[1] sky130_fd_sc_hd__buf_2
XFILLER_48_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3150_ net134 _0072_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3081_ net130 _0039_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2101_ po_0.alu_0.s1 po_0.alu_0.s0 VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and2b_2
X_2032_ net84 po_0._1_\[8\] VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__or2_1
XFILLER_47_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2934_ po_0.regf_0.rf\[2\]\[6\] _0779_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__mux2_1
X_2865_ _1233_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
X_1816_ _0438_ _0440_ _0441_ _0449_ VGND VGND VPWR VPWR po_0.regf_0._3_\[1\] sky130_fd_sc_hd__o22a_1
X_2796_ _1167_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__clkbuf_2
XFILLER_7_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1747_ _0385_ _1429_ _1464_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a21o_1
X_1678_ po_0.regf_0.rf\[8\]\[5\] po_0.regf_0.rf\[9\]\[5\] po_0.regf_0.rf\[10\]\[5\]
+ po_0.regf_0.rf\[11\]\[5\] _1475_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__mux4_1
X_3417_ net184 _0335_ VGND VGND VPWR VPWR uc_0._03_ sky130_fd_sc_hd__dfxtp_1
X_3348_ net140 _0266_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3279_ net160 _0201_ VGND VGND VPWR VPWR uc_0._20_\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2650_ _1082_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1601_ _1404_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__clkbuf_2
X_2581_ _1044_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
X_1532_ _1349_ _1351_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__or2b_1
X_3202_ net100 _0124_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3133_ net140 _0059_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3064_ net136 _0022_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2015_ _0623_ po_0._1_\[6\] VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nor2_1
XFILLER_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2917_ po_0.regf_0.rf\[3\]\[15\] _0871_ _1243_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__mux2_1
XFILLER_50_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2848_ _1223_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
X_2779_ _1176_ _1180_ _1167_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__a21oi_1
XFILLER_58_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_252 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2702_ _1110_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_9_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2633_ _1072_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__buf_2
X_2564_ _1035_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
X_1515_ _1343_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__clkbuf_1
X_2495_ _0997_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
X_3116_ po_0.regf_0._3_\[10\] net88 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dlxtp_1
XFILLER_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3047_ net57 _0578_ _1323_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__mux2_1
XFILLER_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout92 net94 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_1
XFILLER_80_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2280_ _0680_ _0864_ _0854_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__nand3b_1
XFILLER_77_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1995_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__buf_2
XFILLER_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2616_ po_0.regf_0.rf\[11\]\[8\] _0978_ _1061_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__mux2_1
X_2547_ _1025_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
X_2478_ _0839_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__clkbuf_2
XFILLER_55_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1780_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__buf_2
XFILLER_6_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3381_ net142 _0299_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2401_ _0874_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__clkbuf_2
XFILLER_34_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2332_ po_0.regf_0.rf\[6\]\[0\] _0706_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__mux2_1
XFILLER_69_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2263_ _0849_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2194_ po_0.alu_0._11_\[7\] _1339_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__or2b_1
XFILLER_65_420 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1978_ po_0._1_\[1\] _0591_ _0583_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2950_ po_0.regf_0.rf\[2\]\[14\] _0858_ _1262_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__mux2_1
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2881_ _1241_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
X_1901_ _0520_ _0522_ _0524_ _0526_ VGND VGND VPWR VPWR po_0.regf_0._3_\[9\] sky130_fd_sc_hd__o22a_1
XFILLER_30_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1832_ _0453_ _0459_ _0464_ VGND VGND VPWR VPWR po_0.regf_0._3_\[2\] sky130_fd_sc_hd__o21a_1
X_1763_ _0398_ _0399_ _1428_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
X_1694_ _1408_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__buf_2
X_3433_ po_0.alu_0._10_\[8\] _1499_ VGND VGND VPWR VPWR po_0.alu_0._11_\[8\] sky130_fd_sc_hd__ebufn_1
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3364_ net139 _0282_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2315_ po_0.regf_0.rf\[5\]\[9\] _0812_ _0886_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__mux2_1
XFILLER_57_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3295_ net164 _0213_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfxtp_2
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2246_ _0814_ _0815_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__o21a_1
XFILLER_72_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2177_ _0771_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_15_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput36 net36 VGND VGND VPWR VPWR D_W_data[10] sky130_fd_sc_hd__clkbuf_4
Xoutput58 net58 VGND VGND VPWR VPWR D_addr[7] sky130_fd_sc_hd__buf_2
Xoutput47 net47 VGND VGND VPWR VPWR D_W_data[6] sky130_fd_sc_hd__buf_2
Xoutput69 net69 VGND VGND VPWR VPWR I_addr[2] sky130_fd_sc_hd__buf_2
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_353 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3080_ net136 _0038_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2100_ po_0.alu_0.s1 _1336_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__nor2_2
X_2031_ net84 po_0._1_\[8\] VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_1
XFILLER_35_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2933_ _1262_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__clkbuf_4
X_2864_ po_0.regf_0.rf\[8\]\[6\] _0779_ _1232_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__mux2_1
X_2795_ _1193_ _1194_ _1167_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21oi_1
X_1815_ _0444_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__mux2_1
X_1746_ po_0.regf_0.rf\[4\]\[12\] po_0.regf_0.rf\[5\]\[12\] po_0.regf_0.rf\[6\]\[12\]
+ po_0.regf_0.rf\[7\]\[12\] _1425_ _1426_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__mux4_1
XFILLER_7_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1677_ _1408_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__clkbuf_4
X_3416_ net183 _0334_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
X_3347_ net135 _0265_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3278_ net160 _0200_ VGND VGND VPWR VPWR uc_0._20_\[8\] sky130_fd_sc_hd__dfxtp_1
X_2229_ _0727_ po_0.alu_0._11_\[10\] _0718_ net36 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__a22oi_1
XFILLER_41_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_31 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1600_ _0006_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__clkbuf_2
X_2580_ po_0.regf_0.rf\[12\]\[8\] _0978_ _1041_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__mux2_1
X_1531_ _1353_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__clkbuf_1
X_3201_ net106 _0123_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3132_ net139 _0058_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3063_ net155 _0021_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2014_ _0623_ po_0._1_\[6\] VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__and2_1
XFILLER_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2916_ _1260_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2847_ po_0.regf_0.rf\[4\]\[15\] _0871_ _1205_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__mux2_1
X_2778_ _1178_ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__nand2_1
X_1729_ po_0.regf_0.rf\[8\]\[10\] po_0.regf_0.rf\[9\]\[10\] po_0.regf_0.rf\[10\]\[10\]
+ po_0.regf_0.rf\[11\]\[10\] _1421_ _1422_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__mux4_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2701_ net82 net23 _1098_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__mux2_1
XFILLER_9_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2632_ _0877_ _0917_ _0874_ _0897_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__and4b_2
XFILLER_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2563_ po_0.regf_0.rf\[12\]\[0\] _0958_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__mux2_1
X_1514_ _1338_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__or2b_1
X_2494_ po_0.regf_0.rf\[14\]\[1\] _0963_ _0995_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__mux2_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3115_ po_0.regf_0._3_\[9\] net89 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dlxtp_1
XFILLER_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3046_ _1330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout93 net94 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_2
XFILLER_6_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1994_ net85 po_0._1_\[4\] VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__and2_1
X_2615_ _1063_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_2546_ po_0.regf_0.rf\[13\]\[9\] _0980_ _1021_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__mux2_1
X_2477_ _0985_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3029_ uc_0.bc_0._54_\[1\] _1383_ uc_0.bc_0._54_\[2\] _1386_ po_0.muxf_0.s1 VGND
+ VGND VPWR VPWR _1322_ sky130_fd_sc_hd__a41o_1
XFILLER_51_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2400_ _0936_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_3380_ net139 _0298_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2331_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__clkbuf_4
X_2262_ po_0.regf_0.rf\[7\]\[13\] _0848_ _0712_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__mux2_1
XFILLER_69_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2193_ _0783_ _0775_ _0784_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__and3_1
XFILLER_65_432 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1977_ _1370_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__inv_2
X_2529_ po_0.regf_0.rf\[13\]\[1\] _0963_ _1014_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__mux2_1
XFILLER_75_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_78 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2880_ po_0.regf_0.rf\[8\]\[14\] _0858_ _1224_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux2_1
X_1900_ _0415_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__and2b_1
XFILLER_42_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1831_ _0460_ _0428_ _0461_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a211o_1
XFILLER_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1762_ po_0.regf_0.rf\[4\]\[14\] po_0.regf_0.rf\[5\]\[14\] po_0.regf_0.rf\[6\]\[14\]
+ po_0.regf_0.rf\[7\]\[14\] _0342_ _0343_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__mux4_1
X_1693_ _1406_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_4
X_3432_ po_0.alu_0._10_\[7\] _1498_ VGND VGND VPWR VPWR po_0.alu_0._11_\[7\] sky130_fd_sc_hd__ebufn_1
X_3363_ net137 _0281_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2314_ _0889_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_3294_ net180 _0212_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfxtp_1
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2245_ net37 po_0._1_\[11\] _0825_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2176_ po_0.regf_0.rf\[7\]\[5\] _0770_ _0713_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__mux2_1
XFILLER_53_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput37 net37 VGND VGND VPWR VPWR D_W_data[11] sky130_fd_sc_hd__buf_2
Xoutput48 net48 VGND VGND VPWR VPWR D_W_data[7] sky130_fd_sc_hd__buf_2
XFILLER_0_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput59 net59 VGND VGND VPWR VPWR D_rd sky130_fd_sc_hd__buf_2
XFILLER_29_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2030_ _0637_ _0638_ VGND VGND VPWR VPWR po_0.alu_0._10_\[7\] sky130_fd_sc_hd__nor2_1
XFILLER_47_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_468 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2932_ _1269_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
X_2863_ _1224_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__buf_2
X_2794_ _1186_ _1187_ _1190_ _1192_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__a22o_1
X_1814_ _0002_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__buf_2
X_1745_ _1438_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__and2b_1
X_1676_ _1406_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__buf_4
X_3415_ net164 _0333_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfxtp_1
X_3346_ net131 _0264_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3277_ net164 _0199_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2228_ _0650_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nor2_1
X_2159_ _0607_ _0608_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__nor3_4
XFILLER_13_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1530_ _1349_ _1351_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__or2b_1
X_3200_ net103 _0122_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3131_ net121 _0057_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3062_ net153 _0020_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2013_ net47 VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_23_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2915_ po_0.regf_0.rf\[3\]\[14\] _0858_ _1243_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__mux2_1
X_2846_ _1222_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_2777_ net72 po_0.muxf_0.rf_w_data\[5\] _1177_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__or3_1
X_1728_ _0368_ _1417_ _1436_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a21bo_1
X_1659_ _1459_ _1417_ _1418_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__a21bo_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3329_ net138 _0247_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2700_ _1109_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
X_2631_ _1071_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2562_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__buf_2
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1513_ _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2493_ _0996_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
X_3114_ po_0.regf_0._3_\[8\] net88 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dlxtp_1
XFILLER_67_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3045_ net56 _0576_ _1323_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__mux2_1
XFILLER_63_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2829_ po_0.regf_0.rf\[4\]\[6\] _0779_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__mux2_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout83 net39 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_2
XFILLER_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout94 po_0.regf_0.rq_rd VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_2
XFILLER_6_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1993_ _0605_ VGND VGND VPWR VPWR po_0.alu_0._10_\[3\] sky130_fd_sc_hd__clkbuf_1
X_2614_ po_0.regf_0.rf\[11\]\[7\] _0976_ _1061_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__mux2_1
X_2545_ _1024_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
X_2476_ po_0.regf_0.rf\[15\]\[11\] _0984_ _0974_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__mux2_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3028_ po_0.muxf_0.s0 _1321_ _1303_ _0574_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o211a_1
XFILLER_34_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2330_ _0707_ _0875_ _0897_ _0877_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__and4b_4
X_2261_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2192_ _0783_ _0775_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__a21oi_1
XFILLER_65_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1976_ net87 po_0._1_\[2\] VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__nand2b_1
X_2528_ _1015_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_2459_ _0779_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__clkbuf_2
XFILLER_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1830_ _0457_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__and2b_1
X_1761_ po_0.regf_0.rf\[0\]\[14\] po_0.regf_0.rf\[1\]\[14\] po_0.regf_0.rf\[2\]\[14\]
+ po_0.regf_0.rf\[3\]\[14\] _0338_ _0339_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__mux4_1
X_1692_ po_0.regf_0.rf\[0\]\[6\] po_0.regf_0.rf\[1\]\[6\] po_0.regf_0.rf\[2\]\[6\]
+ po_0.regf_0.rf\[3\]\[6\] _1475_ _1476_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__mux4_1
X_3431_ po_0.alu_0._10_\[6\] _1497_ VGND VGND VPWR VPWR po_0.alu_0._11_\[6\] sky130_fd_sc_hd__ebufn_1
X_3362_ net130 _0280_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2313_ po_0.regf_0.rf\[5\]\[8\] _0804_ _0886_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__mux2_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3293_ net181 _0211_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfxtp_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2244_ _0659_ _0651_ _0650_ _0657_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__and4_1
XFILLER_38_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2175_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__clkbuf_2
XFILLER_53_403 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1959_ _0576_ po_0.regf_0.rq_addr\[1\] _0574_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__mux2_1
Xoutput49 net84 VGND VGND VPWR VPWR D_W_data[8] sky130_fd_sc_hd__buf_2
Xoutput38 net38 VGND VGND VPWR VPWR D_W_data[12] sky130_fd_sc_hd__buf_2
XFILLER_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_428 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2931_ po_0.regf_0.rf\[2\]\[5\] _0769_ _1263_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__mux2_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2862_ _1231_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
X_2793_ _1186_ _1187_ _1190_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__nand4_1
X_1813_ po_0.regf_0.rf\[4\]\[1\] po_0.regf_0.rf\[5\]\[1\] po_0.regf_0.rf\[6\]\[1\]
+ po_0.regf_0.rf\[7\]\[1\] _0445_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__mux4_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1744_ po_0.regf_0.rf\[0\]\[12\] po_0.regf_0.rf\[1\]\[12\] po_0.regf_0.rf\[2\]\[12\]
+ po_0.regf_0.rf\[3\]\[12\] _1439_ _1440_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__mux4_1
XFILLER_7_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1675_ _0006_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__buf_2
X_3414_ net164 _0332_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfxtp_1
X_3345_ net135 _0263_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3276_ net164 _0198_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[6\] sky130_fd_sc_hd__dfxtp_1
X_2227_ _0814_ _0800_ po_0._1_\[9\] _0644_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__o2bb2a_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2158_ _0731_ _0751_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__a21oi_2
X_2089_ _0682_ _0685_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a21oi_1
XFILLER_41_406 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_299 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3130_ net131 _0056_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3061_ net161 _0019_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2012_ _0622_ VGND VGND VPWR VPWR po_0.alu_0._10_\[5\] sky130_fd_sc_hd__clkbuf_1
XFILLER_50_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2914_ _1259_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
X_2845_ po_0.regf_0.rf\[4\]\[14\] _0858_ _1205_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
X_2776_ net72 _0576_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__o21ai_1
X_1727_ po_0.regf_0.rf\[12\]\[10\] po_0.regf_0.rf\[13\]\[10\] po_0.regf_0.rf\[14\]\[10\]
+ po_0.regf_0.rf\[15\]\[10\] _1413_ _1415_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__mux4_1
X_1658_ po_0.regf_0.rf\[12\]\[3\] po_0.regf_0.rf\[13\]\[3\] po_0.regf_0.rf\[14\]\[3\]
+ po_0.regf_0.rf\[15\]\[3\] _1413_ _1415_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__mux4_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3328_ net153 _0246_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1589_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__clkbuf_4
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ net148 _0181_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2630_ po_0.regf_0.rf\[11\]\[15\] _0992_ _1053_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__mux2_1
X_2561_ _0711_ _0917_ _0875_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__and4_2
X_1512_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__buf_2
X_2492_ po_0.regf_0.rf\[14\]\[0\] _0958_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__mux2_1
XFILLER_4_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3113_ po_0.regf_0._3_\[7\] net89 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dlxtp_1
X_3044_ _1329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2828_ _1205_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__clkbuf_4
X_2759_ _1161_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nand2_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout95 net75 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout84 net49 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_4
XFILLER_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1992_ _0600_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__and2_1
X_2613_ _1062_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
X_2544_ po_0.regf_0.rf\[13\]\[8\] _0978_ _1021_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__mux2_1
X_2475_ _0829_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__clkbuf_2
XFILLER_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3027_ _1386_ _1383_ _1302_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__a21oi_1
XFILLER_70_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_283 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2260_ net5 _0793_ _0845_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a22o_2
X_2191_ _0633_ _0634_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nor2_1
XFILLER_1_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1975_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2527_ po_0.regf_0.rf\[13\]\[0\] _0958_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__mux2_1
X_2458_ _0972_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2389_ po_0.regf_0.rf\[9\]\[10\] _0822_ _0926_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__mux2_1
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_26 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1760_ _1405_ _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2b_1
X_1691_ _1438_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__and2b_1
X_3430_ po_0.alu_0._10_\[5\] _1496_ VGND VGND VPWR VPWR po_0.alu_0._11_\[5\] sky130_fd_sc_hd__ebufn_1
X_3361_ net135 _0279_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2312_ _0888_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3292_ net183 _0210_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfxtp_2
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2243_ _0831_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2174_ _0765_ _0766_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__a31o_2
XFILLER_53_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1958_ po_0.muxf_0.rf_w_data\[5\] VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__buf_2
X_1889_ po_0.regf_0.rf\[8\]\[8\] po_0.regf_0.rf\[9\]\[8\] po_0.regf_0.rf\[10\]\[8\]
+ po_0.regf_0.rf\[11\]\[8\] _0442_ _0443_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__mux4_1
Xoutput39 net39 VGND VGND VPWR VPWR D_W_data[13] sky130_fd_sc_hd__buf_2
XFILLER_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_220 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_201 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2930_ _1268_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2861_ po_0.regf_0.rf\[8\]\[5\] _0769_ _1225_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__mux2_1
X_2792_ net95 _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__or2_1
X_1812_ _0001_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__clkbuf_4
X_1743_ _0381_ _1445_ _1418_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__a21bo_1
XFILLER_7_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1674_ _1467_ _1469_ _1471_ _1473_ VGND VGND VPWR VPWR po_0.regf_0._5_\[4\] sky130_fd_sc_hd__o22a_1
X_3413_ net164 _0331_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfxtp_1
X_3344_ net174 _0262_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3275_ net162 _0197_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[5\] sky130_fd_sc_hd__dfxtp_1
X_2226_ _0800_ _0814_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__a21oi_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2157_ _0752_ po_0._1_\[2\] net43 _0598_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a31o_1
X_2088_ _0686_ _0687_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__or3b_1
XFILLER_26_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3060_ net161 _0018_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2011_ _0620_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__or2_1
XFILLER_82_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2913_ po_0.regf_0.rf\[3\]\[13\] _0847_ _1243_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__mux2_1
XFILLER_31_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2844_ _1221_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
X_2775_ net73 po_0.muxf_0.rf_w_data\[6\] VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__xnor2_1
X_1726_ _1438_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__and2b_1
X_1657_ _1405_ _1457_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__and2b_1
X_1588_ uc_0.bc_0._54_\[1\] _1384_ _1389_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__o31a_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3327_ net153 _0245_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3258_ net148 _0180_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3189_ net100 _0111_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2209_ _1340_ po_0.alu_0._11_\[8\] _0718_ net84 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__a22o_1
XFILLER_66_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2560_ _0708_ _0709_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__nor2_1
X_2491_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__buf_2
X_1511_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__clkbuf_2
XFILLER_4_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3112_ po_0.regf_0._3_\[6\] net90 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dlxtp_1
X_3043_ net55 _0573_ _1324_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__mux2_1
XFILLER_67_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2827_ _1212_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
X_2758_ _1123_ _0741_ _1159_ _1160_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__or4bb_1
X_1709_ _1438_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__and2b_1
X_2689_ uc_0._20_\[9\] net32 _1099_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__mux2_1
XFILLER_58_101 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout96 net68 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_4
XFILLER_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout85 net45 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_2
XFILLER_6_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1991_ _0598_ _0599_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__or3b_1
XFILLER_13_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2612_ po_0.regf_0.rf\[11\]\[6\] _0973_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__mux2_1
XFILLER_62_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2543_ _1023_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
X_2474_ _0983_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3026_ _1320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2190_ _0623_ po_0._1_\[6\] VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand2_1
XFILLER_1_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1974_ po_0._1_\[2\] net87 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__or2b_1
XFILLER_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2526_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__buf_2
XFILLER_29_17 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2457_ po_0.regf_0.rf\[15\]\[5\] _0971_ _0961_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
XFILLER_29_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2388_ _0930_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3009_ po_0.regf_0.rp_addr\[1\] uc_0._20_\[9\] _1398_ VGND VGND VPWR VPWR _1310_
+ sky130_fd_sc_hd__mux2_1
XFILLER_71_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_251 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1690_ po_0.regf_0.rf\[8\]\[6\] po_0.regf_0.rf\[9\]\[6\] po_0.regf_0.rf\[10\]\[6\]
+ po_0.regf_0.rf\[11\]\[6\] _1439_ _1440_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__mux4_1
X_3360_ net169 _0278_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2311_ po_0.regf_0.rf\[5\]\[7\] _0791_ _0886_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3291_ net183 _0209_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfxtp_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2242_ po_0.regf_0.rf\[7\]\[11\] _0830_ _0781_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_1
X_2173_ _0576_ _0693_ _0696_ net12 VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a22o_1
XFILLER_38_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1957_ _0575_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_1888_ _0514_ _0481_ _0461_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a21o_1
X_2509_ po_0.regf_0.rf\[14\]\[8\] _0978_ _1002_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__mux2_1
XFILLER_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_107 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_335 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2860_ _1230_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1811_ _0000_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_4
X_2791_ net74 po_0.muxf_0.rf_w_data\[7\] VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__nor2_1
X_1742_ po_0.regf_0.rf\[12\]\[12\] po_0.regf_0.rf\[13\]\[12\] po_0.regf_0.rf\[14\]\[12\]
+ po_0.regf_0.rf\[15\]\[12\] _1432_ _1433_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux4_2
XFILLER_7_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1673_ _1472_ _1429_ _1464_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__a21o_1
X_3412_ net182 _0330_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfxtp_1
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3343_ net169 _0261_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3274_ net180 _0196_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[4\] sky130_fd_sc_hd__dfxtp_1
X_2225_ _0644_ po_0._1_\[9\] _0650_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__o21ai_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2156_ net86 po_0._1_\[3\] VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__or2_1
X_2087_ po_0._1_\[14\] net40 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__or2b_1
X_2989_ _1367_ _1378_ _1383_ _1386_ _1390_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a221o_1
XFILLER_21_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2010_ _0610_ _0619_ _0615_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nor3_1
XFILLER_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2912_ _1258_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2843_ po_0.regf_0.rf\[4\]\[13\] _0847_ _1205_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__mux2_1
X_2774_ _1169_ _1174_ _1173_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a21oi_1
X_1725_ po_0.regf_0.rf\[0\]\[10\] po_0.regf_0.rf\[1\]\[10\] po_0.regf_0.rf\[2\]\[10\]
+ po_0.regf_0.rf\[3\]\[10\] _1439_ _1440_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__mux4_1
X_1656_ po_0.regf_0.rf\[8\]\[3\] po_0.regf_0.rf\[9\]\[3\] po_0.regf_0.rf\[10\]\[3\]
+ po_0.regf_0.rf\[11\]\[3\] _1407_ _1409_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__mux4_1
X_1587_ _1384_ _1394_ _1379_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__or3_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3326_ net154 _0244_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ net150 _0179_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3188_ net113 _0110_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_2208_ _0798_ _0659_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nand2_1
X_2139_ _0736_ _0694_ _0697_ net9 VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a22o_1
XFILLER_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2490_ _0711_ _0917_ _0937_ _0897_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__and4_2
X_1510_ po_0.alu_0.s1 VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_4_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3111_ po_0.regf_0._3_\[5\] net90 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dlxtp_1
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3042_ _1328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2826_ po_0.regf_0.rf\[4\]\[5\] _0769_ _1206_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__mux2_1
X_2757_ _1123_ _0741_ _1159_ _1160_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__a2bb2o_1
X_1708_ po_0.regf_0.rf\[8\]\[8\] po_0.regf_0.rf\[9\]\[8\] po_0.regf_0.rf\[10\]\[8\]
+ po_0.regf_0.rf\[11\]\[8\] _1439_ _1440_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__mux4_1
XFILLER_2_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2688_ _1103_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
X_1639_ _1438_ _1441_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__and2b_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3309_ net176 _0227_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout97 net61 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_2
XFILLER_22_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout86 net44 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_2
XFILLER_10_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1990_ _0601_ _0602_ _0589_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__o21a_1
XFILLER_60_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2611_ _1053_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__clkbuf_4
X_2542_ po_0.regf_0.rf\[13\]\[7\] _0976_ _1021_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__mux2_1
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2473_ po_0.regf_0.rf\[15\]\[10\] _0982_ _0974_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__mux2_1
XFILLER_68_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3025_ _1319_ _0917_ _1304_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__mux2_1
XFILLER_36_341 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2809_ _1200_ _1385_ _1390_ _1392_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__and4_1
XFILLER_3_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1973_ po_0._1_\[1\] VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__inv_2
X_2525_ _0711_ _0917_ _0937_ _0876_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__and4_2
X_2456_ _0769_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__clkbuf_2
XFILLER_29_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2387_ po_0.regf_0.rf\[9\]\[9\] _0812_ _0926_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__mux2_1
X_3008_ _1309_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3290_ net181 _0208_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfxtp_1
X_2310_ _0887_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2241_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__clkbuf_2
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2172_ _0699_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__buf_2
XFILLER_80_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1956_ _0573_ po_0.regf_0.rq_addr\[0\] _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__mux2_1
X_1887_ po_0.regf_0.rf\[4\]\[8\] po_0.regf_0.rf\[5\]\[8\] po_0.regf_0.rf\[6\]\[8\]
+ po_0.regf_0.rf\[7\]\[8\] _0478_ _0479_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__mux4_1
X_2508_ _1004_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
X_2439_ po_0.regf_0.w_addr\[2\] po_0.regf_0.w_addr\[3\] _0874_ VGND VGND VPWR VPWR
+ _0959_ sky130_fd_sc_hd__and3_1
XFILLER_71_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1810_ po_0.regf_0.rf\[0\]\[1\] po_0.regf_0.rf\[1\]\[1\] po_0.regf_0.rf\[2\]\[1\]
+ po_0.regf_0.rf\[3\]\[1\] _0442_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux4_1
X_2790_ net74 _0580_ net95 VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__or3b_1
X_1741_ _1474_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__and2b_1
X_1672_ po_0.regf_0.rf\[4\]\[4\] po_0.regf_0.rf\[5\]\[4\] po_0.regf_0.rf\[6\]\[4\]
+ po_0.regf_0.rf\[7\]\[4\] _1425_ _1426_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux4_1
X_3411_ net177 _0329_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfxtp_1
X_3342_ net171 _0260_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ net180 _0195_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[3\] sky130_fd_sc_hd__dfxtp_1
X_2224_ net49 po_0._1_\[8\] po_0._1_\[9\] _0644_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a22oi_2
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2155_ _0588_ _0590_ _0598_ _0599_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a211oi_1
XFILLER_26_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2086_ net41 po_0._1_\[15\] VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__nor2_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2988_ _1299_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
X_1939_ _0559_ _0484_ _0429_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21o_1
XFILLER_67_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2911_ po_0.regf_0.rf\[3\]\[12\] _0839_ _1243_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__mux2_1
X_2842_ _1220_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
X_2773_ _1169_ _1174_ _1175_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__a21oi_1
X_1724_ _0364_ _1435_ _1436_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a21o_1
XFILLER_7_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1655_ _1456_ VGND VGND VPWR VPWR po_0.regf_0._5_\[2\] sky130_fd_sc_hd__clkbuf_1
X_1586_ net98 net81 _1387_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__or3b_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3325_ net154 _0243_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3256_ net150 _0178_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ _0639_ _0640_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a21o_1
X_3187_ net113 _0109_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2138_ po_0.muxf_0.rf_w_data\[2\] VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__buf_2
X_2069_ net83 po_0._1_\[13\] VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__xnor2_2
XFILLER_22_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3110_ po_0.regf_0._3_\[4\] net88 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dlxtp_1
XFILLER_0_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3041_ net54 _0741_ _1324_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux2_1
XFILLER_67_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2825_ _1211_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
X_2756_ net71 po_0.muxf_0.rf_w_data\[4\] VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__nand2_1
X_1707_ _0349_ _1435_ _1486_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__a21bo_1
X_2687_ uc_0._20_\[8\] net31 _1099_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__mux2_1
X_1638_ po_0.regf_0.rf\[0\]\[1\] po_0.regf_0.rf\[1\]\[1\] po_0.regf_0.rf\[2\]\[1\]
+ po_0.regf_0.rf\[3\]\[1\] _1439_ _1440_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__mux4_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1569_ net79 net98 uc_0.bc_0._55_\[0\] VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__nor3b_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3308_ net168 _0226_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3239_ net117 _0161_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout87 net43 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_2
Xfanout98 net82 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_2
XFILLER_13_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2610_ _1060_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
X_2541_ _1022_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
X_2472_ _0821_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__clkbuf_2
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3024_ _0741_ uc_0._20_\[11\] _1397_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__mux2_1
XFILLER_36_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2808_ _1379_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2739_ _1142_ _1143_ _1132_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__nand3_1
XFILLER_1_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_231 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1972_ _0583_ _0586_ VGND VGND VPWR VPWR po_0.alu_0._10_\[1\] sky130_fd_sc_hd__xor2_1
XFILLER_60_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2524_ _1012_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_2455_ _0970_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_2386_ _0929_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3007_ po_0.regf_0.rp_addr\[0\] uc_0._20_\[8\] _1399_ VGND VGND VPWR VPWR _1309_
+ sky130_fd_sc_hd__mux2_1
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_481 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_315 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2240_ net3 _0793_ _0824_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2171_ _0616_ _0698_ _1336_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__or3_1
XFILLER_65_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1955_ _1397_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__clkbuf_2
X_1886_ _0448_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__and2b_1
X_2507_ po_0.regf_0.rf\[14\]\[7\] _0976_ _1002_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__mux2_1
X_2438_ _0705_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__clkbuf_2
XFILLER_29_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2369_ _0920_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
XFILLER_44_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1740_ po_0.regf_0.rf\[8\]\[12\] po_0.regf_0.rf\[9\]\[12\] po_0.regf_0.rf\[10\]\[12\]
+ po_0.regf_0.rf\[11\]\[12\] _1475_ _1476_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__mux4_1
XFILLER_7_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1671_ _1420_ _1470_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__and2b_1
X_3410_ net162 _0328_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfxtp_1
X_3341_ net171 _0259_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3272_ net177 _0194_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[2\] sky130_fd_sc_hd__dfxtp_1
X_2223_ _0813_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2154_ _0750_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_2085_ net41 po_0._1_\[15\] VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__and2_1
XFILLER_61_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2987_ _0872_ po_0.regf_0.rf\[0\]\[15\] _1281_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__mux2_1
X_1938_ po_0.regf_0.rf\[12\]\[14\] po_0.regf_0.rf\[13\]\[14\] po_0.regf_0.rf\[14\]\[14\]
+ po_0.regf_0.rf\[15\]\[14\] _0450_ _0451_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__mux4_1
X_1869_ _0497_ _0415_ _0429_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__a21o_1
XFILLER_67_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2910_ _1257_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XFILLER_73_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2841_ po_0.regf_0.rf\[4\]\[12\] _0839_ _1205_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__mux2_1
XFILLER_31_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2772_ _1169_ _1174_ _1166_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__o21bai_1
X_1723_ po_0.regf_0.rf\[4\]\[10\] po_0.regf_0.rf\[5\]\[10\] po_0.regf_0.rf\[6\]\[10\]
+ po_0.regf_0.rf\[7\]\[10\] _1432_ _1433_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__mux4_1
X_1654_ _1452_ _1455_ _1436_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__mux2_1
X_1585_ uc_0.bc_0._54_\[3\] uc_0.bc_0._54_\[2\] _1384_ VGND VGND VPWR VPWR _1393_
+ sky130_fd_sc_hd__o21ai_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3324_ net122 _0242_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3255_ net118 _0177_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2206_ _0794_ _0754_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__o21bai_2
X_3186_ net100 _0108_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2137_ _0727_ po_0.alu_0._11_\[2\] _0728_ net87 _0734_ VGND VGND VPWR VPWR _0735_
+ sky130_fd_sc_hd__a221o_1
XFILLER_66_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2068_ po_0._1_\[12\] VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__inv_2
XFILLER_22_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_487 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3040_ _1327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2824_ po_0.regf_0.rf\[4\]\[4\] _0760_ _1206_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__mux2_1
X_2755_ net71 po_0.muxf_0.rf_w_data\[4\] VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__or2_1
X_1706_ po_0.regf_0.rf\[12\]\[8\] po_0.regf_0.rf\[13\]\[8\] po_0.regf_0.rf\[14\]\[8\]
+ po_0.regf_0.rf\[15\]\[8\] _1446_ _1447_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__mux4_1
X_2686_ _1102_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
X_1637_ _1414_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__clkbuf_4
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3307_ net171 _0225_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1568_ _1379_ VGND VGND VPWR VPWR uc_0.bc_0._54_\[1\] sky130_fd_sc_hd__clkinv_2
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3238_ net147 _0160_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3169_ net142 _0091_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_129 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout99 net81 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_4
Xfanout88 net89 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_2
XFILLER_10_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2540_ po_0.regf_0.rf\[13\]\[6\] _0973_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__mux2_1
XFILLER_5_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2471_ _0981_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3023_ _1318_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2807_ _1167_ _1198_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__nor2_1
X_2738_ net68 po_0.muxf_0.rf_w_data\[1\] _1142_ _1143_ VGND VGND VPWR VPWR _1144_
+ sky130_fd_sc_hd__a2bb2o_1
X_2669_ _1091_ net17 _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__mux2_1
XFILLER_75_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_243 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1971_ _0584_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__or2_1
XFILLER_60_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2523_ po_0.regf_0.rf\[14\]\[15\] _0992_ _0994_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__mux2_1
X_2454_ po_0.regf_0.rf\[15\]\[4\] _0969_ _0961_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__mux2_1
X_2385_ po_0.regf_0.rf\[9\]\[8\] _0804_ _0926_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux2_1
XFILLER_83_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput1 D_R_data[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
XFILLER_83_246 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3006_ _1308_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_327 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2170_ po_0.alu_0._11_\[5\] _0732_ _0763_ _0764_ _0718_ VGND VGND VPWR VPWR _0765_
+ sky130_fd_sc_hd__a221o_1
XFILLER_80_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_143 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1954_ po_0.muxf_0.rf_w_data\[4\] VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__clkbuf_2
X_1885_ po_0.regf_0.rf\[0\]\[8\] po_0.regf_0.rf\[1\]\[8\] po_0.regf_0.rf\[2\]\[8\]
+ po_0.regf_0.rf\[3\]\[8\] _0442_ _0443_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__mux4_1
XFILLER_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2506_ _1003_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
X_2437_ _0957_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_2368_ po_0.regf_0.rf\[9\]\[0\] _0706_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__mux2_1
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2299_ _0881_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_71_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1670_ po_0.regf_0.rf\[0\]\[4\] po_0.regf_0.rf\[1\]\[4\] po_0.regf_0.rf\[2\]\[4\]
+ po_0.regf_0.rf\[3\]\[4\] _1421_ _1422_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux4_1
X_3340_ net174 _0258_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ net183 _0193_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2222_ po_0.regf_0.rf\[7\]\[9\] _0812_ _0781_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__mux2_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2153_ po_0.regf_0.rf\[7\]\[3\] _0749_ _0713_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__mux2_1
X_2084_ _0682_ _0685_ VGND VGND VPWR VPWR po_0.alu_0._10_\[14\] sky130_fd_sc_hd__xor2_1
XFILLER_53_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_452 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2986_ _1298_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
X_1937_ _0552_ _0554_ _0558_ VGND VGND VPWR VPWR po_0.regf_0._3_\[13\] sky130_fd_sc_hd__o21a_1
X_1868_ po_0.regf_0.rf\[12\]\[6\] po_0.regf_0.rf\[13\]\[6\] po_0.regf_0.rf\[14\]\[6\]
+ po_0.regf_0.rf\[15\]\[6\] _0410_ _0412_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux4_1
X_1799_ _0421_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__clkbuf_4
XFILLER_67_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2840_ _1219_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
XFILLER_73_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2771_ _1172_ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__nor2_1
X_1722_ _0357_ _0359_ _0361_ _0363_ VGND VGND VPWR VPWR po_0.regf_0._5_\[9\] sky130_fd_sc_hd__o22a_1
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1653_ _1453_ _1454_ _0006_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__mux2_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1584_ _1392_ VGND VGND VPWR VPWR uc_0.bc_0._54_\[2\] sky130_fd_sc_hd__inv_2
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3323_ net154 _0241_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3254_ net148 _0176_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2205_ _0632_ po_0._1_\[7\] _0795_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__o22a_1
XFILLER_66_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3185_ net106 _0107_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2136_ _0729_ _0730_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a21oi_1
X_2067_ _0667_ _0668_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__and2_1
XFILLER_81_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2969_ _0780_ po_0.regf_0.rf\[0\]\[6\] _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__mux2_1
XFILLER_22_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_388 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2823_ _1210_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
X_2754_ _1123_ _1128_ _1150_ _1158_ _1126_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o221a_1
X_1705_ _0348_ VGND VGND VPWR VPWR po_0.regf_0._5_\[7\] sky130_fd_sc_hd__clkbuf_1
X_2685_ _0580_ net30 _1099_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__mux2_1
X_1636_ _1412_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__clkbuf_4
X_1567_ _1367_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nand2_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3306_ net178 _0224_ VGND VGND VPWR VPWR uc_0._00_ sky130_fd_sc_hd__dfxtp_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3237_ net102 _0159_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3168_ net142 _0090_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2119_ _0700_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__clkbuf_2
XFILLER_64_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3099_ po_0.regf_0._5_\[9\] net92 VGND VGND VPWR VPWR po_0._1_\[9\] sky130_fd_sc_hd__dlxtp_1
XFILLER_10_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout89 net90 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_2
XFILLER_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2470_ po_0.regf_0.rf\[15\]\[9\] _0980_ _0974_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__mux2_1
XFILLER_79_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3022_ _1317_ _0711_ _1304_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__mux2_1
XFILLER_51_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2806_ _1195_ _1199_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nor2_1
X_2737_ net69 po_0.muxf_0.rf_w_data\[2\] VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__nand2_1
X_2668_ uc_0._03_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__buf_2
X_1619_ po_0.regf_0.rf\[0\]\[0\] po_0.regf_0.rf\[1\]\[0\] po_0.regf_0.rf\[2\]\[0\]
+ po_0.regf_0.rf\[3\]\[0\] _1421_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux4_1
X_2599_ po_0.regf_0.rf\[11\]\[0\] _0958_ _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__mux2_1
XFILLER_74_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_255 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1970_ _1370_ po_0._1_\[1\] VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__and2b_1
XFILLER_81_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2522_ _1011_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
XFILLER_53_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2453_ _0760_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__clkbuf_2
X_2384_ _0928_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
Xinput2 D_R_data[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_68_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3005_ _0580_ po_0.regf_0.rq_addr\[3\] _0581_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__mux2_1
XFILLER_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_303 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_258 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1953_ _0567_ _0569_ _0441_ _0572_ VGND VGND VPWR VPWR po_0.regf_0._3_\[15\] sky130_fd_sc_hd__o22a_1
X_1884_ _0505_ _0507_ _0509_ _0511_ VGND VGND VPWR VPWR po_0.regf_0._3_\[7\] sky130_fd_sc_hd__o22a_1
X_2505_ po_0.regf_0.rf\[14\]\[6\] _0973_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__mux2_1
X_2436_ po_0.regf_0.rf\[1\]\[15\] _0872_ _0939_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__mux2_1
XFILLER_29_406 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2367_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__buf_2
X_2298_ po_0.regf_0.rf\[5\]\[1\] _0725_ _0879_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__mux2_1
XFILLER_56_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3270_ net183 _0192_ VGND VGND VPWR VPWR po_0.muxf_0.rf_w_data\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2221_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__clkbuf_2
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2152_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__clkbuf_2
X_2083_ _0677_ _0665_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__o21bai_1
XFILLER_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2985_ _0859_ po_0.regf_0.rf\[0\]\[14\] _1281_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__mux2_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1936_ _0555_ _0428_ _0461_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a211o_1
X_1867_ _0490_ _0492_ _0494_ _0496_ VGND VGND VPWR VPWR po_0.regf_0._3_\[5\] sky130_fd_sc_hd__o22a_1
X_1798_ _0419_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__clkbuf_4
X_2419_ _0948_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
X_3399_ net158 _0317_ VGND VGND VPWR VPWR po_0.regf_0.rp_addr\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_29_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_364 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2770_ _1170_ _1171_ _1159_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__a21boi_1
X_1721_ _0362_ _1429_ _1464_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__a21o_1
X_1652_ po_0.regf_0.rf\[12\]\[2\] po_0.regf_0.rf\[13\]\[2\] po_0.regf_0.rf\[14\]\[2\]
+ po_0.regf_0.rf\[15\]\[2\] _0004_ _0005_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__mux4_1
X_1583_ _1391_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__clkbuf_2
X_3322_ net115 _0240_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3253_ net101 _0175_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3184_ net103 _0106_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2204_ _0617_ _0624_ _0625_ _0774_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__nor4b_1
X_2135_ _0601_ _0731_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__a21o_1
XFILLER_66_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2066_ _0665_ _0669_ VGND VGND VPWR VPWR po_0.alu_0._10_\[12\] sky130_fd_sc_hd__xnor2_1
XFILLER_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2968_ _1281_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__clkbuf_4
X_1919_ _0536_ _0538_ _0540_ _0542_ VGND VGND VPWR VPWR po_0.regf_0._3_\[11\] sky130_fd_sc_hd__o22a_1
X_2899_ po_0.regf_0.rf\[3\]\[6\] _0779_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__mux2_1
XFILLER_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2822_ po_0.regf_0.rf\[4\]\[3\] _0748_ _1206_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__mux2_1
XFILLER_31_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2753_ _1151_ _1156_ _1157_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__o21ba_1
X_1704_ _0344_ _0345_ _0346_ _0347_ _1428_ _1436_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__mux4_1
XFILLER_8_460 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2684_ _1101_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
X_1635_ _1404_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__clkbuf_2
X_1566_ uc_0.bc_0._55_\[2\] uc_0.bc_0._55_\[3\] _1369_ _1377_ VGND VGND VPWR VPWR
+ _1378_ sky130_fd_sc_hd__o31ai_4
X_3305_ net179 _0223_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfxtp_2
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3236_ net113 _0158_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3167_ net139 _0089_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3098_ po_0.regf_0._5_\[8\] net91 VGND VGND VPWR VPWR po_0._1_\[8\] sky130_fd_sc_hd__dlxtp_1
X_2118_ _0584_ _0585_ _1365_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__o21bai_2
XFILLER_66_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2049_ _0650_ _0654_ VGND VGND VPWR VPWR po_0.alu_0._10_\[10\] sky130_fd_sc_hd__xor2_1
XFILLER_80_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_194 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3021_ _0736_ uc_0._20_\[10\] _1397_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__mux2_1
XFILLER_63_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2805_ _1195_ _1199_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__nor2_1
X_2736_ net69 po_0.muxf_0.rf_w_data\[2\] VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__or2_1
X_2667_ po_0.muxf_0.rf_w_data\[0\] VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__buf_2
X_1618_ _1414_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__buf_2
X_2598_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__buf_2
X_1549_ _1362_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__clkbuf_1
X_3219_ net114 _0141_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2521_ po_0.regf_0.rf\[14\]\[14\] _0990_ _0994_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__mux2_1
XFILLER_5_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2452_ _0968_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_2383_ po_0.regf_0.rf\[9\]\[7\] _0791_ _0926_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__mux2_1
XFILLER_56_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput3 D_R_data[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
X_3004_ _1307_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2719_ _1116_ _1118_ _1126_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__o21a_1
XFILLER_3_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_315 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_120 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_307 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1952_ _0570_ _0571_ _0457_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__mux2_1
X_1883_ _0510_ _0458_ _0441_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a21o_1
X_2504_ _0994_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__buf_2
X_2435_ _0956_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XFILLER_29_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2366_ _0877_ _0917_ _0875_ _0876_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__and4b_2
X_2297_ _0880_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_78 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_440 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_487 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2220_ net16 _0793_ _0809_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__a22o_2
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_395 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2151_ _0741_ _0694_ _0697_ net10 _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a221o_2
X_2082_ net83 _0683_ _0679_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__a21o_1
XFILLER_19_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ _1297_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
X_1935_ _0457_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__and2b_1
X_1866_ _0432_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__and2b_1
X_1797_ _0414_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_2
X_2418_ po_0.regf_0.rf\[1\]\[6\] _0780_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__mux2_1
X_3398_ net157 _0316_ VGND VGND VPWR VPWR po_0.regf_0.rp_addr\[2\] sky130_fd_sc_hd__dfxtp_1
X_2349_ po_0.regf_0.rf\[6\]\[8\] _0804_ _0906_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__mux2_1
XFILLER_84_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_465 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_325 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1720_ po_0.regf_0.rf\[4\]\[9\] po_0.regf_0.rf\[5\]\[9\] po_0.regf_0.rf\[6\]\[9\]
+ po_0.regf_0.rf\[7\]\[9\] _1425_ _1426_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__mux4_1
X_1651_ po_0.regf_0.rf\[8\]\[2\] po_0.regf_0.rf\[9\]\[2\] po_0.regf_0.rf\[10\]\[2\]
+ po_0.regf_0.rf\[11\]\[2\] _1406_ _1408_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__mux4_1
X_3321_ net107 _0239_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_1582_ net34 net98 net99 _1387_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__or4b_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3252_ net103 _0174_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3183_ net104 _0105_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2203_ _0623_ po_0._1_\[6\] po_0._1_\[7\] _0632_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a22o_1
X_2134_ _1339_ po_0.alu_0.s0 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__or2b_2
XFILLER_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2065_ _0667_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__nand2_1
X_2967_ _1288_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
X_2898_ _1243_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__buf_2
X_1918_ _0541_ _0428_ _0461_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a21o_1
X_1849_ po_0.regf_0.rf\[12\]\[4\] po_0.regf_0.rf\[13\]\[4\] po_0.regf_0.rf\[14\]\[4\]
+ po_0.regf_0.rf\[15\]\[4\] _0478_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux4_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2821_ _1209_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
XFILLER_76_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2752_ _1156_ _1151_ _1113_ uc_0._00_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__a211o_1
XFILLER_8_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1703_ po_0.regf_0.rf\[12\]\[7\] po_0.regf_0.rf\[13\]\[7\] po_0.regf_0.rf\[14\]\[7\]
+ po_0.regf_0.rf\[15\]\[7\] _0342_ _0343_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__mux4_1
X_2683_ _0578_ net29 _1099_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__mux2_1
X_1634_ _1434_ _1435_ _1436_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__a21o_1
X_1565_ _1371_ _1376_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__nand2_2
X_3304_ net180 _0222_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dfxtp_2
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3235_ net114 _0157_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3166_ net135 _0088_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_3097_ po_0.regf_0._5_\[7\] net94 VGND VGND VPWR VPWR po_0._1_\[7\] sky130_fd_sc_hd__dlxtp_1
X_2117_ _0701_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__buf_2
X_2048_ _0641_ _0643_ _0645_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a31oi_2
XFILLER_22_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3020_ _1316_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
X_2804_ _1195_ _1199_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__nor2_1
X_2735_ net97 po_0.muxf_0.rf_w_data\[0\] _1135_ _1133_ VGND VGND VPWR VPWR _1141_
+ sky130_fd_sc_hd__a2bb2oi_1
X_2666_ _1090_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
X_1617_ _1412_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__clkbuf_4
X_2597_ _0708_ _0709_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__and3_2
X_1548_ _1348_ _1350_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__or2b_1
XFILLER_59_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3218_ net100 _0140_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3149_ net126 _0071_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_30 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2520_ _1010_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XFILLER_5_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2451_ po_0.regf_0.rf\[15\]\[3\] _0967_ _0961_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__mux2_1
X_2382_ _0927_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_257 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput4 D_R_data[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
X_3003_ _0578_ po_0.regf_0.rq_addr\[2\] _0581_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__mux2_1
XFILLER_36_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2718_ _1119_ _1122_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nor3b_2
XFILLER_10_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2649_ po_0.regf_0.rf\[10\]\[7\] _0976_ _1080_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__mux2_1
XFILLER_55_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_371 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1951_ po_0.regf_0.rf\[4\]\[15\] po_0.regf_0.rf\[5\]\[15\] po_0.regf_0.rf\[6\]\[15\]
+ po_0.regf_0.rf\[7\]\[15\] _0409_ _0411_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__mux4_1
X_1882_ po_0.regf_0.rf\[4\]\[7\] po_0.regf_0.rf\[5\]\[7\] po_0.regf_0.rf\[6\]\[7\]
+ po_0.regf_0.rf\[7\]\[7\] _0454_ _0455_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux4_1
X_2503_ _1001_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
X_2434_ po_0.regf_0.rf\[1\]\[14\] _0859_ _0939_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__mux2_1
X_2365_ po_0.regf_0.w_addr\[3\] VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2296_ po_0.regf_0.rf\[5\]\[0\] _0706_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__mux2_1
XFILLER_24_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_20 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_455 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ net86 _0698_ _1336_ _0699_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__o311a_1
X_2081_ po_0._1_\[13\] VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__inv_2
XFILLER_53_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2983_ _0848_ po_0.regf_0.rf\[0\]\[13\] _1281_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__mux2_1
XFILLER_14_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1934_ po_0.regf_0.rf\[0\]\[13\] po_0.regf_0.rf\[1\]\[13\] po_0.regf_0.rf\[2\]\[13\]
+ po_0.regf_0.rf\[3\]\[13\] _0419_ _0421_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__mux4_1
X_1865_ po_0.regf_0.rf\[8\]\[5\] po_0.regf_0.rf\[9\]\[5\] po_0.regf_0.rf\[10\]\[5\]
+ po_0.regf_0.rf\[11\]\[5\] _0433_ _0434_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__mux4_1
X_1796_ _0427_ _0428_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a21o_1
X_2417_ _0939_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__clkbuf_4
X_3397_ net163 _0315_ VGND VGND VPWR VPWR po_0.regf_0.rp_addr\[1\] sky130_fd_sc_hd__dfxtp_1
X_2348_ _0908_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2279_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__inv_2
XFILLER_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1650_ _1450_ _1451_ _1404_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__mux2_1
X_1581_ _1390_ VGND VGND VPWR VPWR uc_0.bc_0._54_\[3\] sky130_fd_sc_hd__inv_2
X_3320_ net123 _0238_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3251_ net117 _0173_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_3182_ net134 _0104_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2202_ _0612_ _0619_ _0629_ _0784_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand4_1
X_2133_ _0591_ _0587_ _0717_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__o21ai_2
XFILLER_81_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2064_ _0666_ po_0._1_\[12\] VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__or2_1
XFILLER_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2966_ _0770_ po_0.regf_0.rf\[0\]\[5\] _1282_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux2_1
X_1917_ po_0.regf_0.rf\[4\]\[11\] po_0.regf_0.rf\[5\]\[11\] po_0.regf_0.rf\[6\]\[11\]
+ po_0.regf_0.rf\[7\]\[11\] _0425_ _0426_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__mux4_1
X_2897_ _1250_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_1848_ _0411_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_4
X_1779_ _0002_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_1_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_88 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2820_ po_0.regf_0.rf\[4\]\[2\] _0738_ _1206_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__mux2_1
X_2751_ _1154_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__nand2_1
X_1702_ po_0.regf_0.rf\[8\]\[7\] po_0.regf_0.rf\[9\]\[7\] po_0.regf_0.rf\[10\]\[7\]
+ po_0.regf_0.rf\[11\]\[7\] _0342_ _0343_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__mux4_1
X_2682_ _1100_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
X_1633_ _0007_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__clkbuf_4
X_1564_ _1372_ _1373_ _1374_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__and4_1
X_3303_ net179 _0221_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfxtp_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3234_ net103 _0156_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3165_ net130 _0087_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3096_ po_0.regf_0._5_\[6\] net93 VGND VGND VPWR VPWR po_0._1_\[6\] sky130_fd_sc_hd__dlxtp_1
X_2116_ po_0._1_\[0\] _1363_ _0584_ _0585_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__a211o_1
XFILLER_54_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2047_ _0646_ _0651_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__o21ai_1
X_2949_ _1278_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XFILLER_77_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2803_ _1195_ _1199_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nor2_1
X_2734_ _1138_ _1111_ _1139_ _1129_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a31o_1
X_2665_ po_0.regf_0.rf\[10\]\[15\] _0992_ _1072_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__mux2_1
X_2596_ po_0.regf_0.w_addr\[2\] po_0.regf_0.w_addr\[3\] _0874_ VGND VGND VPWR VPWR
+ _1052_ sky130_fd_sc_hd__and3b_1
X_1616_ _1404_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__clkbuf_2
XFILLER_5_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1547_ _1361_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__clkbuf_1
X_3217_ net126 _0139_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3148_ net133 _0070_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_111 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3079_ net155 _0037_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2450_ _0748_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__clkbuf_2
X_2381_ po_0.regf_0.rf\[9\]\[6\] _0780_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
XFILLER_68_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput5 D_R_data[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
XFILLER_49_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3002_ _1306_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2717_ _1123_ _1124_ net96 net97 VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__nand4_1
X_2648_ _1081_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_2579_ _1043_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
XFILLER_27_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1950_ po_0.regf_0.rf\[0\]\[15\] po_0.regf_0.rf\[1\]\[15\] po_0.regf_0.rf\[2\]\[15\]
+ po_0.regf_0.rf\[3\]\[15\] _0445_ _0446_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__mux4_1
X_1881_ _0484_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__and2b_1
X_2502_ po_0.regf_0.rf\[14\]\[5\] _0971_ _0995_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__mux2_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2433_ _0955_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_2364_ _0916_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_2295_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__buf_2
XFILLER_24_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_486 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_21 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_10 net64 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_386 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_486 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_412 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2080_ _0680_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or2_1
XFILLER_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2982_ _1296_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
X_1933_ po_0.regf_0.rf\[4\]\[13\] po_0.regf_0.rf\[5\]\[13\] po_0.regf_0.rf\[6\]\[13\]
+ po_0.regf_0.rf\[7\]\[13\] _0425_ _0426_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__mux4_1
Xinput30 I_data[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dlymetal6s2s_1
X_1864_ _0493_ _0428_ _0430_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__a21o_1
X_1795_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__buf_2
X_2416_ _0946_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3396_ net159 _0314_ VGND VGND VPWR VPWR po_0.regf_0.rp_addr\[0\] sky130_fd_sc_hd__dfxtp_1
X_2347_ po_0.regf_0.rf\[6\]\[7\] _0791_ _0906_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__mux2_1
XFILLER_84_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2278_ _0686_ _0687_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__or2_1
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1580_ _1389_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__clkbuf_2
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3250_ net101 _0172_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3181_ net126 _0103_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2201_ _0696_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__buf_2
X_2132_ _0591_ _0587_ _0717_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__o21a_1
XFILLER_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2063_ _0666_ po_0._1_\[12\] VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__nand2_1
X_2965_ _1287_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
X_1916_ _0418_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2b_1
X_2896_ po_0.regf_0.rf\[3\]\[5\] _0769_ _1244_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__mux2_1
X_1847_ _0409_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__buf_4
X_1778_ po_0.regf_0.rf\[4\]\[0\] po_0.regf_0.rf\[5\]\[0\] po_0.regf_0.rf\[6\]\[0\]
+ po_0.regf_0.rf\[7\]\[0\] _0410_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux4_1
X_3379_ net137 _0297_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2750_ _1124_ _0736_ _1152_ _1153_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__or4bb_1
X_1701_ po_0.regf_0.rf\[4\]\[7\] po_0.regf_0.rf\[5\]\[7\] po_0.regf_0.rf\[6\]\[7\]
+ po_0.regf_0.rf\[7\]\[7\] _0342_ _0343_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__mux4_1
X_2681_ _0576_ net28 _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__mux2_1
X_1632_ _1404_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__buf_2
X_1563_ net46 net85 net48 net47 VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__nor4_1
X_3302_ net179 _0220_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfxtp_2
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3233_ net126 _0155_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3164_ net135 _0086_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3095_ po_0.regf_0._5_\[5\] net93 VGND VGND VPWR VPWR po_0._1_\[5\] sky130_fd_sc_hd__dlxtp_1
X_2115_ _0714_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_2046_ po_0._1_\[9\] _0644_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__or2b_1
XFILLER_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_278 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2948_ po_0.regf_0.rf\[2\]\[13\] _0847_ _1262_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__mux2_1
X_2879_ _1240_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_34 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2802_ _1195_ _1199_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__nor2_1
XFILLER_81_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2733_ _1124_ _1127_ _1115_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nand3_1
X_2664_ _1089_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
X_2595_ _1051_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
X_1615_ _1416_ _1417_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__a21bo_1
X_1546_ _1348_ _1350_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__or2b_1
XFILLER_5_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3216_ net104 _0138_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3147_ net153 _0069_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3078_ net170 _0036_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2029_ _0628_ _0633_ _0634_ _0635_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__nor4_1
XFILLER_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2380_ _0918_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__buf_2
XFILLER_68_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 D_R_data[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3001_ _0576_ po_0.regf_0.rq_addr\[1\] _0581_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__mux2_1
XFILLER_64_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2716_ net69 VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__clkbuf_2
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2647_ po_0.regf_0.rf\[10\]\[6\] _0973_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__mux2_1
X_2578_ po_0.regf_0.rf\[12\]\[7\] _0976_ _1041_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__mux2_1
X_1529_ _1352_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__clkbuf_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1880_ po_0.regf_0.rf\[0\]\[7\] po_0.regf_0.rf\[1\]\[7\] po_0.regf_0.rf\[2\]\[7\]
+ po_0.regf_0.rf\[3\]\[7\] _0433_ _0434_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux4_1
X_2501_ _1000_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
X_2432_ po_0.regf_0.rf\[1\]\[13\] _0848_ _0939_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__mux2_1
XFILLER_44_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2363_ po_0.regf_0.rf\[6\]\[15\] _0872_ _0898_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__mux2_1
X_2294_ _0707_ _0875_ _0876_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__and4b_4
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_22 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_11 net69 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_424 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2981_ _0840_ po_0.regf_0.rf\[0\]\[12\] _1281_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__mux2_1
X_1932_ _0553_ _0458_ _0430_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a21o_1
X_1863_ po_0.regf_0.rf\[12\]\[5\] po_0.regf_0.rf\[13\]\[5\] po_0.regf_0.rf\[14\]\[5\]
+ po_0.regf_0.rf\[15\]\[5\] _0425_ _0426_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__mux4_1
Xinput20 I_data[12] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput31 I_data[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_2
X_1794_ _0003_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__inv_2
X_2415_ po_0.regf_0.rf\[1\]\[5\] _0770_ _0940_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__mux2_1
X_3395_ net177 _0313_ VGND VGND VPWR VPWR po_0.regf_0.rq_addr\[3\] sky130_fd_sc_hd__dfxtp_1
X_2346_ _0907_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_2277_ net41 _1341_ _1337_ _0861_ _0767_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__o311a_1
XFILLER_16_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2200_ _0792_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3180_ net127 _0102_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2131_ _0589_ _0590_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__and2_1
X_2062_ net38 VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_81_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2964_ _0761_ po_0.regf_0.rf\[0\]\[4\] _1282_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__mux2_1
X_1915_ po_0.regf_0.rf\[0\]\[11\] po_0.regf_0.rf\[1\]\[11\] po_0.regf_0.rf\[2\]\[11\]
+ po_0.regf_0.rf\[3\]\[11\] _0420_ _0422_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__mux4_1
XFILLER_30_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2895_ _1249_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
X_1846_ _0473_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and2b_1
X_1777_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__clkbuf_4
X_3378_ net130 _0296_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2329_ po_0.regf_0.w_addr\[0\] po_0.regf_0.w_addr\[1\] VGND VGND VPWR VPWR _0897_
+ sky130_fd_sc_hd__and2b_1
XFILLER_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1700_ po_0.regf_0.rf\[0\]\[7\] po_0.regf_0.rf\[1\]\[7\] po_0.regf_0.rf\[2\]\[7\]
+ po_0.regf_0.rf\[3\]\[7\] _0342_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__mux4_1
X_2680_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__buf_2
XFILLER_8_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1631_ po_0.regf_0.rf\[4\]\[1\] po_0.regf_0.rf\[5\]\[1\] po_0.regf_0.rf\[6\]\[1\]
+ po_0.regf_0.rf\[7\]\[1\] _1432_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux4_1
X_3301_ net179 _0219_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfxtp_1
X_1562_ net50 net84 net37 net36 VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nor4_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3232_ net104 _0154_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3163_ net168 _0085_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2114_ po_0.regf_0.rf\[7\]\[0\] _0706_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__mux2_1
XFILLER_81_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3094_ po_0.regf_0._5_\[4\] net93 VGND VGND VPWR VPWR po_0._1_\[4\] sky130_fd_sc_hd__dlxtp_1
XFILLER_66_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2045_ net50 po_0._1_\[9\] VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__xor2_2
XFILLER_47_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2947_ _1277_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
X_2878_ po_0.regf_0.rf\[8\]\[13\] _0847_ _1224_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
X_1829_ po_0.regf_0.rf\[0\]\[2\] po_0.regf_0.rf\[1\]\[2\] po_0.regf_0.rf\[2\]\[2\]
+ po_0.regf_0.rf\[3\]\[2\] _0419_ _0421_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__mux4_1
XFILLER_38_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2801_ _1195_ _1199_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__nor2_1
X_2732_ _1127_ _1115_ _1124_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a21o_1
X_2663_ po_0.regf_0.rf\[10\]\[14\] _0990_ _1072_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__mux2_1
X_2594_ po_0.regf_0.rf\[12\]\[15\] _0992_ _1033_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__mux2_1
X_1614_ _0007_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__clkbuf_2
X_1545_ _1360_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__clkbuf_1
X_3215_ net104 _0137_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3146_ net153 _0068_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3077_ net161 _0035_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2028_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__inv_2
XFILLER_35_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 D_R_data[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_49_452 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3000_ _1305_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2715_ net70 VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__clkbuf_2
X_2646_ _1072_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__clkbuf_4
X_2577_ _1042_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
X_1528_ _1349_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__or2b_1
X_3129_ net130 _0055_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2500_ po_0.regf_0.rf\[14\]\[4\] _0969_ _0995_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__mux2_1
XFILLER_41_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2431_ _0954_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_2362_ _0915_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
X_2293_ po_0.regf_0.w_addr\[2\] VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_37_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_12 net72 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_23 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2629_ _1070_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2980_ _1295_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
XFILLER_14_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1931_ po_0.regf_0.rf\[12\]\[13\] po_0.regf_0.rf\[13\]\[13\] po_0.regf_0.rf\[14\]\[13\]
+ po_0.regf_0.rf\[15\]\[13\] _0454_ _0455_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__mux4_1
X_1862_ _0418_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__and2b_1
Xinput10 D_R_data[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_2
Xinput21 I_data[13] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput32 I_data[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
X_1793_ _0414_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__buf_2
X_2414_ _0945_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
X_3394_ net178 _0312_ VGND VGND VPWR VPWR po_0.regf_0.rq_addr\[2\] sky130_fd_sc_hd__dfxtp_1
X_2345_ po_0.regf_0.rf\[6\]\[6\] _0780_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__mux2_1
X_2276_ po_0.alu_0._11_\[15\] _0698_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__or2b_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2130_ _0700_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__clkbuf_4
X_2061_ _0643_ _0660_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a21oi_2
XFILLER_19_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2963_ _1286_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
X_1914_ _0537_ _0432_ _0482_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21o_1
X_2894_ po_0.regf_0.rf\[3\]\[4\] _0760_ _1244_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__mux2_1
X_1845_ po_0.regf_0.rf\[8\]\[4\] po_0.regf_0.rf\[9\]\[4\] po_0.regf_0.rf\[10\]\[4\]
+ po_0.regf_0.rf\[11\]\[4\] _0474_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__mux4_1
X_1776_ _0001_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_2
X_3377_ net135 _0295_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2328_ _0896_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2259_ net83 _0727_ _1337_ _0767_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__o31a_1
XFILLER_25_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_222 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1630_ _1414_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__clkbuf_4
X_3300_ net179 _0218_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfxtp_1
X_1561_ net83 net38 net41 net40 VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__nor4_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3231_ net106 _0153_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3162_ net170 _0084_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2113_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__clkbuf_4
X_3093_ po_0.regf_0._5_\[3\] net94 VGND VGND VPWR VPWR po_0._1_\[3\] sky130_fd_sc_hd__dlxtp_1
XFILLER_66_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2044_ _0648_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand2b_2
XFILLER_81_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2946_ po_0.regf_0.rf\[2\]\[12\] _0839_ _1262_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__mux2_1
X_2877_ _1239_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
X_1828_ _0416_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__buf_2
X_1759_ po_0.regf_0.rf\[8\]\[14\] po_0.regf_0.rf\[9\]\[14\] po_0.regf_0.rf\[10\]\[14\]
+ po_0.regf_0.rf\[11\]\[14\] _1407_ _1409_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__mux4_1
X_3429_ po_0.alu_0._10_\[4\] _1495_ VGND VGND VPWR VPWR po_0.alu_0._11_\[4\] sky130_fd_sc_hd__ebufn_1
XFILLER_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2800_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__clkbuf_2
X_2731_ _1127_ _1128_ _1131_ _1137_ _1126_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o221a_1
X_2662_ _1088_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_67_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2593_ _1050_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
X_1613_ _1404_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__clkbuf_2
X_1544_ _1348_ _1350_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__or2b_1
X_3214_ net133 _0136_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3145_ net154 _0067_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3076_ net161 _0034_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2027_ _0633_ _0634_ _0635_ _0628_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o22ai_4
XFILLER_82_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2929_ po_0.regf_0.rf\[2\]\[4\] _0760_ _1263_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__mux2_1
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput8 D_R_data[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_49_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2714_ net67 _1120_ net66 _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__or4_1
X_2645_ _1079_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2576_ po_0.regf_0.rf\[12\]\[6\] _0973_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__mux2_1
X_1527_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3128_ net136 _0054_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3059_ net168 _0017_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_50_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2430_ po_0.regf_0.rf\[1\]\[12\] _0840_ _0939_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__mux2_1
X_2361_ po_0.regf_0.rf\[6\]\[14\] _0859_ _0898_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__mux2_1
X_2292_ po_0.regf_0.w_addr\[1\] po_0.regf_0.w_addr\[0\] VGND VGND VPWR VPWR _0876_
+ sky130_fd_sc_hd__and2b_1
XFILLER_2_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_13 net74 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2628_ po_0.regf_0.rf\[11\]\[14\] _0990_ _1053_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__mux2_1
X_2559_ _1031_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_278 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1930_ _0432_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__and2b_1
X_1861_ po_0.regf_0.rf\[0\]\[5\] po_0.regf_0.rf\[1\]\[5\] po_0.regf_0.rf\[2\]\[5\]
+ po_0.regf_0.rf\[3\]\[5\] _0420_ _0422_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux4_1
Xinput22 I_data[14] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput11 D_R_data[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput33 clock VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
X_1792_ po_0.regf_0.rf\[12\]\[0\] po_0.regf_0.rf\[13\]\[0\] po_0.regf_0.rf\[14\]\[0\]
+ po_0.regf_0.rf\[15\]\[0\] _0425_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__mux4_1
X_2413_ po_0.regf_0.rf\[1\]\[4\] _0761_ _0940_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__mux2_1
X_3393_ net178 _0311_ VGND VGND VPWR VPWR po_0.regf_0.rq_addr\[1\] sky130_fd_sc_hd__dfxtp_1
X_2344_ _0898_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__buf_2
XFILLER_69_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2275_ _0860_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_201 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2060_ _0661_ po_0._1_\[11\] _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__o21ai_2
XFILLER_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2962_ _0749_ po_0.regf_0.rf\[0\]\[3\] _1282_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__mux2_1
X_1913_ po_0.regf_0.rf\[12\]\[11\] po_0.regf_0.rf\[13\]\[11\] po_0.regf_0.rf\[14\]\[11\]
+ po_0.regf_0.rf\[15\]\[11\] _0410_ _0412_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__mux4_1
X_2893_ _1248_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1844_ _0421_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__clkbuf_4
X_1775_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__buf_4
X_3376_ net174 _0294_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2327_ po_0.regf_0.rf\[5\]\[15\] _0872_ _0878_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__mux2_1
XFILLER_69_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2258_ _0842_ _0843_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__o21ai_1
XFILLER_57_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2189_ _0782_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_399 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_362 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1560_ uc_0.bc_0._55_\[1\] uc_0.bc_0._55_\[2\] uc_0.bc_0._55_\[3\] uc_0.bc_0._55_\[0\]
+ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__and4bb_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3230_ net134 _0152_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3161_ net177 _0083_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2112_ _0707_ _0710_ _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__and3b_4
XFILLER_66_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3092_ po_0.regf_0._5_\[2\] net93 VGND VGND VPWR VPWR po_0._1_\[2\] sky130_fd_sc_hd__dlxtp_1
XFILLER_81_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2043_ po_0._1_\[10\] net36 VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__or2b_1
XFILLER_62_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2945_ _1276_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
X_2876_ po_0.regf_0.rf\[8\]\[12\] _0839_ _1224_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__mux2_1
X_1827_ po_0.regf_0.rf\[4\]\[2\] po_0.regf_0.rf\[5\]\[2\] po_0.regf_0.rf\[6\]\[2\]
+ po_0.regf_0.rf\[7\]\[2\] _0425_ _0426_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__mux4_1
X_1758_ _0394_ _1420_ _1486_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a21bo_1
X_1689_ _1485_ _1435_ _1486_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__a21bo_1
X_3428_ po_0.alu_0._10_\[3\] _1494_ VGND VGND VPWR VPWR po_0.alu_0._11_\[3\] sky130_fd_sc_hd__ebufn_1
XFILLER_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3359_ net169 _0277_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_329 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2730_ _1112_ _1111_ _1134_ _1136_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__and4bb_1
X_2661_ po_0.regf_0.rf\[10\]\[13\] _0988_ _1072_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__mux2_1
X_1612_ po_0.regf_0.rf\[12\]\[0\] po_0.regf_0.rf\[13\]\[0\] po_0.regf_0.rf\[14\]\[0\]
+ po_0.regf_0.rf\[15\]\[0\] _1413_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__mux4_1
X_2592_ po_0.regf_0.rf\[12\]\[14\] _0990_ _1033_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__mux2_1
X_1543_ _1359_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__clkbuf_1
X_3213_ net127 _0135_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3144_ net154 _0066_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3075_ net168 _0033_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2026_ po_0._1_\[6\] _0623_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__and2b_1
XFILLER_54_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2928_ _1267_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2859_ po_0.regf_0.rf\[8\]\[4\] _0760_ _1225_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__mux2_1
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_413 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput9 D_R_data[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_64_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2713_ net65 net64 net63 net62 VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__or4_1
X_2644_ po_0.regf_0.rf\[10\]\[5\] _0971_ _1073_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux2_1
X_2575_ _1033_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__buf_2
X_1526_ _1341_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3127_ net153 _0053_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3058_ net172 _0016_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2009_ _0610_ _0615_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__o21a_1
XFILLER_23_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2360_ _0914_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_2291_ _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_2_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_14 net84 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_25 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2627_ _1069_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_2558_ po_0.regf_0.rf\[13\]\[15\] _0992_ _1013_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__mux2_1
X_2489_ _0993_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
X_1509_ _1337_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__clkbuf_2
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_47 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_195 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1860_ _0489_ _0415_ _0416_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a21o_1
Xinput12 D_R_data[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
X_1791_ _0411_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_4
Xinput23 I_data[15] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_2
Xinput34 reset VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_2
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2412_ _0944_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_3392_ net178 _0310_ VGND VGND VPWR VPWR po_0.regf_0.rq_addr\[0\] sky130_fd_sc_hd__dfxtp_1
X_2343_ _0905_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2274_ po_0.regf_0.rf\[7\]\[14\] _0859_ _0712_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
XFILLER_16_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1989_ _1370_ _0587_ _0592_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__o21ai_1
XFILLER_4_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2961_ _1285_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
X_1912_ _0448_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__and2b_1
XFILLER_8_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2892_ po_0.regf_0.rf\[3\]\[3\] _0748_ _1244_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__mux2_1
X_1843_ _0419_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__clkbuf_4
X_1774_ _0000_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__clkbuf_2
X_3375_ net170 _0293_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2326_ _0895_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2257_ _1341_ po_0.alu_0._11_\[13\] _0728_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2188_ po_0.regf_0.rf\[7\]\[6\] _0780_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__mux2_1
XFILLER_65_360 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3160_ net176 _0082_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3091_ po_0.regf_0._5_\[1\] net93 VGND VGND VPWR VPWR po_0._1_\[1\] sky130_fd_sc_hd__dlxtp_1
X_2111_ po_0.regf_0.w_addr\[2\] VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__clkbuf_2
X_2042_ net36 po_0._1_\[10\] VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__and2b_1
XFILLER_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2944_ po_0.regf_0.rf\[2\]\[11\] _0829_ _1270_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__mux2_1
X_2875_ _1238_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_271 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1826_ _0456_ _0458_ _0430_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__a21o_1
X_1757_ po_0.regf_0.rf\[12\]\[14\] po_0.regf_0.rf\[13\]\[14\] po_0.regf_0.rf\[14\]\[14\]
+ po_0.regf_0.rf\[15\]\[14\] _1446_ _1447_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux4_1
X_1688_ _0007_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__clkbuf_2
X_3427_ po_0.alu_0._10_\[2\] _1493_ VGND VGND VPWR VPWR po_0.alu_0._11_\[2\] sky130_fd_sc_hd__ebufn_1
X_3358_ net172 _0276_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2309_ po_0.regf_0.rf\[5\]\[6\] _0780_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3289_ net177 _0015_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__dfxtp_1
XFILLER_45_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_23 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2660_ _1087_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
X_1611_ _1414_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__clkbuf_4
X_2591_ _1049_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
X_1542_ _1348_ _1350_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__or2b_1
X_3212_ net133 _0134_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3143_ net141 _0065_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3074_ net171 _0032_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2025_ _0632_ po_0._1_\[7\] VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__and2_1
XFILLER_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2927_ po_0.regf_0.rf\[2\]\[3\] _0748_ _1263_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__mux2_1
X_2858_ _1229_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_2789_ _1189_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
X_1809_ _0001_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__clkbuf_4
XFILLER_49_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_425 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2712_ net76 net95 VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__or2_1
XFILLER_72_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2643_ _1078_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
X_2574_ _1040_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
X_1525_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3126_ net156 _0052_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3057_ uc_0._01_ _1204_ _1335_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__a21bo_1
XFILLER_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2008_ _0617_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__nor2_2
XFILLER_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2290_ po_0.regf_0.w_wr VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_15 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2626_ po_0.regf_0.rf\[11\]\[13\] _0988_ _1053_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__mux2_1
X_2557_ _1030_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
X_2488_ po_0.regf_0.rf\[15\]\[15\] _0992_ _0960_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__mux2_1
X_1508_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__clkbuf_2
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3109_ po_0.regf_0._3_\[3\] po_0.regf_0.rp_rd VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dlxtp_1
XFILLER_36_480 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1790_ _0409_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__clkbuf_4
Xinput13 D_R_data[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
XFILLER_52_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput24 I_data[1] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3391_ net150 _0309_ VGND VGND VPWR VPWR po_0.regf_0.w_wr sky130_fd_sc_hd__dfxtp_1
X_2411_ po_0.regf_0.rf\[1\]\[3\] _0749_ _0940_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__mux2_1
XFILLER_35_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2342_ po_0.regf_0.rf\[6\]\[5\] _0770_ _0899_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__mux2_1
X_2273_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1988_ _0589_ _0590_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__nand2_1
X_2609_ po_0.regf_0.rf\[11\]\[5\] _0971_ _1054_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__mux2_1
XFILLER_28_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2960_ _0739_ po_0.regf_0.rf\[0\]\[2\] _1282_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__mux2_1
X_1911_ po_0.regf_0.rf\[8\]\[11\] po_0.regf_0.rf\[9\]\[11\] po_0.regf_0.rf\[10\]\[11\]
+ po_0.regf_0.rf\[11\]\[11\] _0442_ _0443_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__mux4_1
X_2891_ _1247_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1842_ _0002_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__clkbuf_2
XFILLER_8_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1773_ _0402_ _0404_ _0406_ _0408_ VGND VGND VPWR VPWR po_0.regf_0._5_\[15\] sky130_fd_sc_hd__o22a_1
X_3374_ net177 _0292_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2325_ po_0.regf_0.rf\[5\]\[14\] _0859_ _0878_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux2_1
XFILLER_57_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2256_ _0667_ _0672_ _0836_ _0732_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__a31o_1
XFILLER_84_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2187_ _0712_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__clkbuf_4
XFILLER_65_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_424 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2110_ _0708_ _0709_ po_0.regf_0.w_wr VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__and3_1
X_3090_ po_0.regf_0._5_\[0\] net93 VGND VGND VPWR VPWR po_0._1_\[0\] sky130_fd_sc_hd__dlxtp_1
XFILLER_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2041_ _0645_ _0647_ VGND VGND VPWR VPWR po_0.alu_0._10_\[9\] sky130_fd_sc_hd__xor2_1
XFILLER_47_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2943_ _1275_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
X_2874_ po_0.regf_0.rf\[8\]\[11\] _0829_ _1232_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__mux2_1
XFILLER_30_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1825_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__buf_2
XFILLER_30_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1756_ _0388_ _0390_ _1430_ _0393_ VGND VGND VPWR VPWR po_0.regf_0._5_\[13\] sky130_fd_sc_hd__o22a_1
X_1687_ po_0.regf_0.rf\[12\]\[6\] po_0.regf_0.rf\[13\]\[6\] po_0.regf_0.rf\[14\]\[6\]
+ po_0.regf_0.rf\[15\]\[6\] _1446_ _1447_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__mux4_1
X_3426_ po_0.alu_0._10_\[1\] _1492_ VGND VGND VPWR VPWR po_0.alu_0._11_\[1\] sky130_fd_sc_hd__ebufn_1
X_3357_ net172 _0275_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2308_ _0878_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__clkbuf_4
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3288_ net176 _0014_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__dfxtp_1
X_2239_ _1341_ po_0.alu_0._11_\[11\] _0826_ _0827_ _0728_ VGND VGND VPWR VPWR _0828_
+ sky130_fd_sc_hd__a221oi_4
XFILLER_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_117 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1610_ _0005_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2590_ po_0.regf_0.rf\[12\]\[13\] _0988_ _1033_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__mux2_1
X_1541_ _1358_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__clkbuf_1
X_3211_ net146 _0133_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3142_ net154 _0064_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3073_ net115 _0031_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2024_ _0632_ po_0._1_\[7\] VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__nor2_2
X_2926_ _1266_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
X_2857_ po_0.regf_0.rf\[8\]\[3\] _0748_ _1225_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__mux2_1
X_1808_ _0000_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__clkbuf_4
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2788_ _1167_ _1187_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__and3b_1
XFILLER_2_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1739_ _0373_ _0375_ _1430_ _0378_ VGND VGND VPWR VPWR po_0.regf_0._5_\[11\] sky130_fd_sc_hd__o22a_1
XFILLER_49_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3409_ net181 _0327_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfxtp_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_412 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2711_ net74 net73 net72 net71 VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__or4_1
X_2642_ po_0.regf_0.rf\[10\]\[4\] _0969_ _1073_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__mux2_1
X_2573_ po_0.regf_0.rf\[12\]\[5\] _0971_ _1034_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__mux2_1
X_1524_ _1337_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_4_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3125_ net161 _0051_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3056_ _1386_ _1388_ uc_0.bc_0._54_\[0\] _1200_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a211o_1
XFILLER_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2007_ _0616_ po_0._1_\[5\] VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__and2_1
XFILLER_23_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2909_ po_0.regf_0.rf\[3\]\[11\] _0829_ _1251_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__mux2_1
XFILLER_58_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_470 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_16 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2625_ _1068_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
X_2556_ po_0.regf_0.rf\[13\]\[14\] _0990_ _1013_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__mux2_1
X_2487_ _0871_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1507_ po_0.alu_0.s0 VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__clkbuf_2
XFILLER_55_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3108_ po_0.regf_0._3_\[2\] net90 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dlxtp_1
XFILLER_55_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3039_ net53 _0736_ _1324_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__mux2_1
XFILLER_36_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_440 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput14 D_R_data[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
Xinput25 I_data[2] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_2
XFILLER_6_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2410_ _0943_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
X_3390_ net160 _0308_ VGND VGND VPWR VPWR po_0.regf_0.rp_rd sky130_fd_sc_hd__dfxtp_1
X_2341_ _0904_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_2272_ net6 _0697_ _0857_ _0767_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a22o_2
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1987_ _0589_ _0593_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_20_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2608_ _1059_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
X_2539_ _1013_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__buf_2
XFILLER_83_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_14_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1910_ _0528_ _0530_ _0532_ _0534_ VGND VGND VPWR VPWR po_0.regf_0._3_\[10\] sky130_fd_sc_hd__o22a_1
XFILLER_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2890_ po_0.regf_0.rf\[3\]\[2\] _0738_ _1244_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__mux2_1
X_1841_ _0466_ _0468_ _0472_ VGND VGND VPWR VPWR po_0.regf_0._3_\[3\] sky130_fd_sc_hd__o21a_1
XFILLER_8_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1772_ _0407_ _1417_ _1464_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a21o_1
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3373_ net176 _0291_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2324_ _0894_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2255_ _0667_ _0836_ _0672_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__a21oi_1
X_2186_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__clkbuf_2
XFILLER_65_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2040_ _0641_ _0643_ _0646_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a21bo_1
XFILLER_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2942_ po_0.regf_0.rf\[2\]\[10\] _0821_ _1270_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__mux2_1
X_2873_ _1237_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
X_1824_ _0002_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__clkbuf_2
X_1755_ _0391_ _0392_ _1428_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__mux2_1
X_1686_ _1478_ _1480_ _1482_ _1484_ VGND VGND VPWR VPWR po_0.regf_0._5_\[5\] sky130_fd_sc_hd__o22a_1
X_3425_ po_0.alu_0._10_\[0\] _1491_ VGND VGND VPWR VPWR po_0.alu_0._11_\[0\] sky130_fd_sc_hd__ebufn_1
X_3356_ net168 _0274_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2307_ _0885_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3287_ net176 _0013_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__dfxtp_2
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2238_ _0825_ _0816_ _0657_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__o21ai_1
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2169_ _0607_ _0755_ _0619_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__o21ai_1
XFILLER_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_129 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_50 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1540_ _1348_ _1350_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__or2b_1
XFILLER_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3210_ net116 _0132_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3141_ net160 _0011_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__dfxtp_1
X_3072_ net104 _0030_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_2023_ net48 VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__clkbuf_2
X_2925_ po_0.regf_0.rf\[2\]\[2\] _0738_ _1263_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__mux2_1
X_2856_ _1228_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
X_1807_ _0416_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__buf_2
X_2787_ _1185_ _1186_ _1182_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__a21o_1
X_1738_ _0376_ _0377_ _1428_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__mux2_1
X_1669_ _1468_ _1417_ _1418_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a21bo_1
XFILLER_49_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3408_ net158 _0326_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfxtp_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3339_ net173 _0257_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2710_ _1112_ _1111_ _1115_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__and4bb_1
XFILLER_71_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2641_ _1077_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
X_2572_ _1039_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1523_ _1347_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3124_ net161 _0050_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3055_ _1200_ uc_0.bc_0._54_\[3\] uc_0.bc_0._54_\[2\] _1302_ _1334_ VGND VGND VPWR
+ VPWR _0336_ sky130_fd_sc_hd__o311a_1
X_2006_ _0616_ po_0._1_\[5\] VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__nor2_1
XFILLER_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2908_ _1256_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
X_2839_ po_0.regf_0.rf\[4\]\[11\] _0829_ _1213_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__mux2_1
XFILLER_76_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_17 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2624_ po_0.regf_0.rf\[11\]\[12\] _0986_ _1053_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__mux2_1
X_2555_ _1029_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
X_2486_ _0991_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
X_3107_ po_0.regf_0._3_\[1\] net88 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dlxtp_1
X_3038_ _1326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_227 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput26 I_data[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput15 D_R_data[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dlymetal6s2s_1
X_2340_ po_0.regf_0.rf\[6\]\[4\] _0761_ _0899_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__mux2_1
X_2271_ _0854_ _0716_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a31o_1
XFILLER_37_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1986_ net86 po_0._1_\[3\] VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nor2_1
X_2607_ po_0.regf_0.rf\[11\]\[4\] _0969_ _1054_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__mux2_1
X_2538_ _1020_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2469_ _0811_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__clkbuf_2
XFILLER_57_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_367 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout181 net185 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_1
XFILLER_19_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout170 net175 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_444 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1840_ _0469_ _0428_ _0461_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a211o_1
XFILLER_30_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1771_ po_0.regf_0.rf\[4\]\[15\] po_0.regf_0.rf\[5\]\[15\] po_0.regf_0.rf\[6\]\[15\]
+ po_0.regf_0.rf\[7\]\[15\] _1413_ _1415_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__mux4_1
XFILLER_6_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3372_ net143 _0290_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2323_ po_0.regf_0.rf\[5\]\[13\] _0848_ _0878_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__mux2_1
XFILLER_69_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2254_ _0841_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_2185_ _0777_ _0721_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a21o_2
XFILLER_77_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_219 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1969_ po_0._1_\[1\] net42 VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__and2b_1
XFILLER_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_448 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2941_ _1274_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2872_ po_0.regf_0.rf\[8\]\[10\] _0821_ _1232_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__mux2_1
X_1823_ po_0.regf_0.rf\[12\]\[2\] po_0.regf_0.rf\[13\]\[2\] po_0.regf_0.rf\[14\]\[2\]
+ po_0.regf_0.rf\[15\]\[2\] _0454_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__mux4_1
X_1754_ po_0.regf_0.rf\[4\]\[13\] po_0.regf_0.rf\[5\]\[13\] po_0.regf_0.rf\[6\]\[13\]
+ po_0.regf_0.rf\[7\]\[13\] _0342_ _0343_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux4_1
X_3424_ net159 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
X_1685_ _1483_ _1429_ _1464_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__a21o_1
X_3355_ net171 _0273_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2306_ po_0.regf_0.rf\[5\]\[5\] _0770_ _0879_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_3286_ net176 _0012_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__dfxtp_2
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2237_ _0825_ _0657_ _0816_ _0716_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__o31a_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2168_ _0607_ _0619_ _0755_ _0701_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__o31a_1
XFILLER_53_311 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2099_ _0693_ _0695_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nor2_2
XFILLER_53_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_62 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_23 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3140_ net162 _0010_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__dfxtp_1
X_3071_ net122 _0029_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2022_ _0631_ VGND VGND VPWR VPWR po_0.alu_0._10_\[6\] sky130_fd_sc_hd__clkbuf_1
XFILLER_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2924_ _1265_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_2855_ po_0.regf_0.rf\[8\]\[2\] _0738_ _1225_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__mux2_1
X_1806_ _0418_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__and2b_1
X_2786_ _1182_ _1185_ _1186_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__nand3_1
X_1737_ po_0.regf_0.rf\[4\]\[11\] po_0.regf_0.rf\[5\]\[11\] po_0.regf_0.rf\[6\]\[11\]
+ po_0.regf_0.rf\[7\]\[11\] _0338_ _0339_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__mux4_1
X_1668_ po_0.regf_0.rf\[12\]\[4\] po_0.regf_0.rf\[13\]\[4\] po_0.regf_0.rf\[14\]\[4\]
+ po_0.regf_0.rf\[15\]\[4\] _1413_ _1415_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__mux4_1
X_3407_ net173 _0325_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfxtp_1
X_3338_ net102 _0256_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1599_ _1403_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3269_ net101 _0191_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2640_ po_0.regf_0.rf\[10\]\[3\] _0967_ _1073_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__mux2_1
XFILLER_71_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2571_ po_0.regf_0.rf\[12\]\[4\] _0969_ _1034_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__mux2_1
X_1522_ _1338_ _1342_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__or2b_1
X_3123_ net168 _0049_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3054_ _1200_ _1385_ _1390_ _1392_ _1111_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a41o_1
XFILLER_82_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2005_ net46 VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__clkbuf_2
XFILLER_63_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2907_ po_0.regf_0.rf\[3\]\[10\] _0821_ _1251_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__mux2_1
X_2838_ _1218_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
X_2769_ net71 _0573_ _1170_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__and4bb_1
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_18 _1091_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2623_ _1067_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_2554_ po_0.regf_0.rf\[13\]\[13\] _0988_ _1013_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__mux2_1
X_2485_ po_0.regf_0.rf\[15\]\[14\] _0990_ _0960_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__mux2_1
X_3106_ po_0.regf_0._3_\[0\] net90 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dlxtp_1
XFILLER_55_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3037_ net52 _0722_ _1324_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__mux2_1
XFILLER_36_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_328 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput16 D_R_data[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput27 I_data[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_6_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2270_ _1340_ po_0.alu_0._11_\[14\] _0700_ net40 VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a22o_1
XFILLER_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1985_ net86 po_0._1_\[3\] VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__and2_1
X_2606_ _1058_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
X_2537_ po_0.regf_0.rf\[13\]\[5\] _0971_ _1014_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__mux2_1
X_2468_ _0979_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2399_ po_0.regf_0.rf\[9\]\[15\] _0872_ _0918_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__mux2_1
XFILLER_28_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout160 net163 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
Xfanout182 net184 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1770_ _1438_ _0405_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__and2b_1
XFILLER_30_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3440_ po_0.alu_0._10_\[15\] _1506_ VGND VGND VPWR VPWR po_0.alu_0._11_\[15\] sky130_fd_sc_hd__ebufn_1
X_3371_ net172 _0289_ VGND VGND VPWR VPWR po_0.regf_0.rf\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2322_ _0893_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2253_ po_0.regf_0.rf\[7\]\[12\] _0840_ _0712_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux2_1
XFILLER_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2184_ _0578_ _0693_ _0696_ net13 VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a22o_1
XFILLER_65_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1968_ _1363_ po_0._1_\[0\] VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__and2b_1
X_1899_ po_0.regf_0.rf\[8\]\[9\] po_0.regf_0.rf\[9\]\[9\] po_0.regf_0.rf\[10\]\[9\]
+ po_0.regf_0.rf\[11\]\[9\] _0433_ _0434_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__mux4_1
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2940_ po_0.regf_0.rf\[2\]\[9\] _0811_ _1270_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux2_1
XFILLER_62_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2871_ _1236_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1822_ _0411_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__clkbuf_4
XFILLER_30_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1753_ po_0.regf_0.rf\[0\]\[13\] po_0.regf_0.rf\[1\]\[13\] po_0.regf_0.rf\[2\]\[13\]
+ po_0.regf_0.rf\[3\]\[13\] _0338_ _0339_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__mux4_1
X_1684_ po_0.regf_0.rf\[4\]\[5\] po_0.regf_0.rf\[5\]\[5\] po_0.regf_0.rf\[6\]\[5\]
+ po_0.regf_0.rf\[7\]\[5\] _1425_ _1426_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__mux4_1
X_3423_ net184 uc_0.bc_0._54_\[3\] VGND VGND VPWR VPWR uc_0.bc_0._55_\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3354_ net109 _0272_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2305_ _0884_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3285_ net162 _0207_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
X_2236_ net36 po_0._1_\[10\] VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and2_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2167_ _0762_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_53_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2098_ _1339_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__clkbuf_2
XFILLER_80_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3070_ net120 _0028_ VGND VGND VPWR VPWR po_0.regf_0.rf\[7\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2021_ _0628_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__and2b_1
XFILLER_62_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2923_ po_0.regf_0.rf\[2\]\[1\] _0724_ _1263_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__mux2_1
X_2854_ _1227_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
X_1805_ po_0.regf_0.rf\[8\]\[1\] po_0.regf_0.rf\[9\]\[1\] po_0.regf_0.rf\[10\]\[1\]
+ po_0.regf_0.rf\[11\]\[1\] _0420_ _0422_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__mux4_1
X_2785_ net73 _0578_ _1183_ _1184_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a2bb2o_1
X_1736_ po_0.regf_0.rf\[0\]\[11\] po_0.regf_0.rf\[1\]\[11\] po_0.regf_0.rf\[2\]\[11\]
+ po_0.regf_0.rf\[3\]\[11\] _0338_ _0339_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__mux4_1
X_1667_ _1405_ _1466_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__and2b_1
X_1598_ po_0.regf_0.rp_addr\[3\] uc_0._20_\[11\] _1399_ VGND VGND VPWR VPWR _1403_
+ sky130_fd_sc_hd__mux2_1
X_3406_ net183 _0324_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfxtp_1
X_3337_ net103 _0255_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ net103 _0190_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_18 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3199_ net104 _0121_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2219_ _0644_ _0727_ _1337_ _0767_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__o31a_1
XFILLER_26_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_6 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2570_ _1038_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
X_1521_ _1346_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__clkbuf_1
X_3122_ net172 _0048_ VGND VGND VPWR VPWR po_0.regf_0.rf\[6\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3053_ _1092_ _1202_ _1333_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__o21a_1
X_2004_ po_0._1_\[4\] net85 VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__and2b_1
XFILLER_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_359 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2906_ _1255_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
X_2837_ po_0.regf_0.rf\[4\]\[10\] _0821_ _1213_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__mux2_1
X_2768_ net72 po_0.muxf_0.rf_w_data\[5\] VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__or2_1
X_2699_ net99 net22 _1098_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__mux2_1
X_1719_ _1420_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__and2b_1
XFILLER_58_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_167 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_19 net29 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2622_ po_0.regf_0.rf\[11\]\[11\] _0984_ _1061_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__mux2_1
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2553_ _1028_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
X_2484_ _0858_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__clkbuf_2
X_3105_ po_0.regf_0._5_\[15\] net92 VGND VGND VPWR VPWR po_0._1_\[15\] sky130_fd_sc_hd__dlxtp_1
X_3036_ _1325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput17 I_data[0] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 I_data[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_2
XFILLER_6_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_307 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1984_ _0597_ VGND VGND VPWR VPWR po_0.alu_0._10_\[2\] sky130_fd_sc_hd__clkbuf_1
XFILLER_9_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2605_ po_0.regf_0.rf\[11\]\[3\] _0967_ _1054_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__mux2_1
X_2536_ _1019_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
X_2467_ po_0.regf_0.rf\[15\]\[8\] _0978_ _0974_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__mux2_1
X_2398_ _0935_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3019_ _1315_ _0709_ _1304_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__mux2_1
Xfanout183 net184 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_2
Xfanout150 net151 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout172 net175 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_2
Xfanout161 net163 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3370_ net119 _0288_ VGND VGND VPWR VPWR po_0.regf_0.rf\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2321_ po_0.regf_0.rf\[5\]\[12\] _0840_ _0878_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
X_2252_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__clkbuf_2
XFILLER_26_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2183_ _0773_ _0775_ _0716_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a31o_1
XFILLER_80_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1967_ _0582_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_1898_ _0523_ _0481_ _0482_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a21o_1
X_2519_ po_0.regf_0.rf\[14\]\[13\] _0988_ _0994_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__mux2_1
XFILLER_68_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2870_ po_0.regf_0.rf\[8\]\[9\] _0811_ _1232_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__mux2_1
XFILLER_30_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1821_ _0409_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__buf_4
X_1752_ _1405_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__and2b_1
XFILLER_7_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1683_ _1420_ _1481_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__and2b_1
X_3422_ net182 uc_0.bc_0._54_\[2\] VGND VGND VPWR VPWR uc_0.bc_0._55_\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3353_ net110 _0271_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3284_ net114 _0206_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_2
X_2304_ po_0.regf_0.rf\[5\]\[4\] _0761_ _0879_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2235_ _0661_ _0728_ _0696_ _0694_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a211o_1
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2166_ po_0.regf_0.rf\[7\]\[4\] _0761_ _0713_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__mux2_1
XFILLER_80_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2097_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__buf_2
XFILLER_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2999_ _0573_ po_0.regf_0.rq_addr\[0\] _0581_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2020_ _0627_ _0629_ _0626_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand3_1
XFILLER_75_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2922_ _1264_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
X_2853_ po_0.regf_0.rf\[8\]\[1\] _0724_ _1225_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__mux2_1
X_1804_ _0437_ _0415_ _0429_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a21o_1
X_2784_ net73 po_0.muxf_0.rf_w_data\[6\] _1183_ _1184_ VGND VGND VPWR VPWR _1185_
+ sky130_fd_sc_hd__or4bb_1
X_1735_ _1405_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__and2b_1
X_1666_ po_0.regf_0.rf\[8\]\[4\] po_0.regf_0.rf\[9\]\[4\] po_0.regf_0.rf\[10\]\[4\]
+ po_0.regf_0.rf\[11\]\[4\] _1407_ _1409_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux4_1
X_3405_ net173 _0323_ VGND VGND VPWR VPWR po_0.muxf_0.s1 sky130_fd_sc_hd__dfxtp_1
X_1597_ _1402_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_3336_ net118 _0254_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3267_ net118 _0189_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3198_ net128 _0120_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2218_ _1341_ po_0.alu_0._11_\[9\] _0728_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__a211o_1
XFILLER_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2149_ _1340_ po_0.alu_0._11_\[3\] _0700_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a211o_1
XFILLER_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1520_ _1338_ _1342_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__or2b_1
XFILLER_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3121_ po_0.regf_0._3_\[15\] net89 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dlxtp_1
X_3052_ net77 _1201_ _1202_ _1333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o31a_1
X_2003_ _0614_ VGND VGND VPWR VPWR po_0.alu_0._10_\[4\] sky130_fd_sc_hd__clkbuf_1
XFILLER_63_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2905_ po_0.regf_0.rf\[3\]\[9\] _0811_ _1251_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__mux2_1
XFILLER_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2836_ _1217_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
X_2767_ net72 po_0.muxf_0.rf_w_data\[5\] VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__nand2_1
X_1718_ po_0.regf_0.rf\[0\]\[9\] po_0.regf_0.rf\[1\]\[9\] po_0.regf_0.rf\[2\]\[9\]
+ po_0.regf_0.rf\[3\]\[9\] _1421_ _1422_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__mux4_1
X_2698_ _1108_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_1649_ po_0.regf_0.rf\[4\]\[2\] po_0.regf_0.rf\[5\]\[2\] po_0.regf_0.rf\[6\]\[2\]
+ po_0.regf_0.rf\[7\]\[2\] _1406_ _1408_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__mux4_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3319_ net121 _0237_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_179 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2621_ _1066_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
X_2552_ po_0.regf_0.rf\[13\]\[12\] _0986_ _1013_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__mux2_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2483_ _0989_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
X_3104_ po_0.regf_0._5_\[14\] net91 VGND VGND VPWR VPWR po_0._1_\[14\] sky130_fd_sc_hd__dlxtp_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3035_ net51 _1091_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__mux2_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2819_ _1208_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_68 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 I_data[10] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput29 I_data[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XFILLER_6_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1983_ _0593_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and2_1
XFILLER_60_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2604_ _1057_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
X_2535_ po_0.regf_0.rf\[13\]\[4\] _0969_ _1014_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__mux2_1
X_2466_ _0803_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__clkbuf_2
X_2397_ po_0.regf_0.rf\[9\]\[14\] _0859_ _0918_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__mux2_1
XFILLER_68_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3018_ _0722_ uc_0._20_\[9\] _1397_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__mux2_1
XFILLER_24_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_1
Xfanout151 net152 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_1
Xfanout173 net174 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_2
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_1
Xfanout184 net185 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2320_ _0892_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_2251_ net4 _0793_ _0838_ _0767_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__a22o_2
X_2182_ _0698_ po_0.alu_0._11_\[6\] _0718_ _0623_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__a22o_1
XFILLER_18_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1966_ _0580_ po_0.regf_0.rq_addr\[3\] _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__mux2_1
X_1897_ po_0.regf_0.rf\[12\]\[9\] po_0.regf_0.rf\[13\]\[9\] po_0.regf_0.rf\[14\]\[9\]
+ po_0.regf_0.rf\[15\]\[9\] _0478_ _0479_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__mux4_1
X_2518_ _1009_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2449_ _0966_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_325 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1820_ _0432_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__and2b_1
X_1751_ po_0.regf_0.rf\[8\]\[13\] po_0.regf_0.rf\[9\]\[13\] po_0.regf_0.rf\[10\]\[13\]
+ po_0.regf_0.rf\[11\]\[13\] _1407_ _1409_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__mux4_1
XFILLER_7_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1682_ po_0.regf_0.rf\[0\]\[5\] po_0.regf_0.rf\[1\]\[5\] po_0.regf_0.rf\[2\]\[5\]
+ po_0.regf_0.rf\[3\]\[5\] _1421_ _1422_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__mux4_1
X_3421_ net182 uc_0.bc_0._54_\[1\] VGND VGND VPWR VPWR uc_0.bc_0._55_\[1\] sky130_fd_sc_hd__dfxtp_1
X_3352_ net123 _0270_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2303_ _0883_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3283_ net182 _0205_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_2
X_2234_ _0823_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_65_130 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2096_ _0695_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__clkbuf_2
XFILLER_80_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2998_ _0937_ _1204_ _1304_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a21bo_1
X_1949_ _0473_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__and2b_1
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_200 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2921_ po_0.regf_0.rf\[2\]\[0\] _0705_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__mux2_1
X_2852_ _1226_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_1803_ po_0.regf_0.rf\[12\]\[1\] po_0.regf_0.rf\[13\]\[1\] po_0.regf_0.rf\[14\]\[1\]
+ po_0.regf_0.rf\[15\]\[1\] _0410_ _0412_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__mux4_2
X_2783_ net74 po_0.muxf_0.rf_w_data\[7\] VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__or2_1
X_1734_ po_0.regf_0.rf\[8\]\[11\] po_0.regf_0.rf\[9\]\[11\] po_0.regf_0.rf\[10\]\[11\]
+ po_0.regf_0.rf\[11\]\[11\] _1407_ _1409_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__mux4_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1665_ _1458_ _1460_ _1462_ _1465_ VGND VGND VPWR VPWR po_0.regf_0._5_\[3\] sky130_fd_sc_hd__o22a_1
X_3404_ net173 _0322_ VGND VGND VPWR VPWR po_0.muxf_0.s0 sky130_fd_sc_hd__dfxtp_1
X_1596_ po_0.regf_0.rp_addr\[2\] uc_0._20_\[10\] _1399_ VGND VGND VPWR VPWR _1402_
+ sky130_fd_sc_hd__mux2_1
X_3335_ net101 _0253_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3266_ net101 _0188_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2217_ _0806_ _0807_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nor2_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3197_ net126 _0119_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2148_ _0611_ _0743_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a21oi_1
X_2079_ net40 po_0._1_\[14\] VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nor2_1
XFILLER_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_188 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_391 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_424 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3120_ po_0.regf_0._3_\[14\] net88 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dlxtp_1
XFILLER_82_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3051_ uc_0.bc_0._54_\[0\] _1390_ _1392_ _1378_ _1324_ VGND VGND VPWR VPWR _1333_
+ sky130_fd_sc_hd__a41oi_2
X_2002_ _0610_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__and2b_1
XFILLER_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2904_ _1254_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2835_ po_0.regf_0.rf\[4\]\[9\] _0811_ _1213_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__mux2_1
X_2766_ _1163_ _1165_ _1161_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__o21ai_1
X_1717_ _0358_ _1445_ _1418_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21bo_1
X_2697_ net80 net21 _1098_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__mux2_1
X_1648_ po_0.regf_0.rf\[0\]\[2\] po_0.regf_0.rf\[1\]\[2\] po_0.regf_0.rf\[2\]\[2\]
+ po_0.regf_0.rf\[3\]\[2\] _1406_ _1408_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__mux4_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3318_ net144 _0236_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_1579_ _1386_ _1388_ net34 VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__a21o_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3249_ net106 _0171_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_243 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2620_ po_0.regf_0.rf\[11\]\[10\] _0982_ _1061_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__mux2_1
XFILLER_40_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2551_ _1027_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_2482_ po_0.regf_0.rf\[15\]\[13\] _0988_ _0960_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__mux2_1
XFILLER_49_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3103_ po_0.regf_0._5_\[13\] net91 VGND VGND VPWR VPWR po_0._1_\[13\] sky130_fd_sc_hd__dlxtp_1
X_3034_ _1323_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__clkbuf_4
XFILLER_36_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2818_ po_0.regf_0.rf\[4\]\[1\] _0724_ _1206_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__mux2_1
X_2749_ net69 _0736_ _1152_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_486 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 I_data[11] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1982_ _0594_ _0595_ _0589_ _0590_ _0584_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a221o_1
X_2603_ po_0.regf_0.rf\[11\]\[2\] _0965_ _1054_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__mux2_1
X_2534_ _1018_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_2465_ _0977_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_2396_ _0934_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3017_ _1314_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout130 net132 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout141 net144 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout152 net167 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_1
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_2
Xfanout163 net166 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout185 net186 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_1
XFILLER_47_76 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_20 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2250_ _0727_ po_0.alu_0._11_\[12\] _0718_ _0666_ _0837_ VGND VGND VPWR VPWR _0838_
+ sky130_fd_sc_hd__a221o_1
XFILLER_69_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2181_ _0616_ po_0._1_\[5\] _0774_ _0755_ _0629_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__o221ai_4
XFILLER_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1965_ _1396_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__clkbuf_2
X_1896_ _0473_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__and2b_1
X_2517_ po_0.regf_0.rf\[14\]\[12\] _0986_ _0994_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__mux2_1
X_2448_ po_0.regf_0.rf\[15\]\[2\] _0965_ _0961_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__mux2_1
X_2379_ _0925_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
XFILLER_16_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_437 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1750_ _0387_ _1435_ _1486_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__a21bo_1
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1681_ _1479_ _1445_ _1418_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__a21bo_1
X_3420_ net184 uc_0.bc_0._54_\[0\] VGND VGND VPWR VPWR uc_0.bc_0._55_\[0\] sky130_fd_sc_hd__dfxtp_1
X_3351_ net120 _0269_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2302_ po_0.regf_0.rf\[5\]\[3\] _0749_ _0879_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
X_3282_ net158 _0204_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_2
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2233_ po_0.regf_0.rf\[7\]\[10\] _0822_ _0781_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2164_ _0758_ _0721_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21o_2
XFILLER_65_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2095_ po_0.muxf_0.s1 po_0.muxf_0.s0 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__and2b_1
XFILLER_80_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2997_ _1385_ _1302_ _1303_ _0581_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__o211a_2
X_1948_ po_0.regf_0.rf\[8\]\[15\] po_0.regf_0.rf\[9\]\[15\] po_0.regf_0.rf\[10\]\[15\]
+ po_0.regf_0.rf\[11\]\[15\] _0474_ _0475_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__mux4_1
X_1879_ _0506_ _0481_ _0482_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a21o_1
XFILLER_28_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2920_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__buf_2
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2851_ po_0.regf_0.rf\[8\]\[0\] _0705_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__mux2_1
X_2782_ net74 po_0.muxf_0.rf_w_data\[7\] VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__nand2_1
X_1802_ _0417_ _0424_ _0431_ _0436_ VGND VGND VPWR VPWR po_0.regf_0._3_\[0\] sky130_fd_sc_hd__o22a_1
X_1733_ _0372_ _1435_ _1486_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__a21bo_1
XFILLER_7_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1664_ _1463_ _1429_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__a21o_1
X_3403_ net151 _0321_ VGND VGND VPWR VPWR po_0.regf_0.w_addr\[3\] sky130_fd_sc_hd__dfxtp_1
X_1595_ _1401_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_3334_ net129 _0252_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3265_ net107 _0187_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2216_ _0639_ _0645_ _0800_ _0732_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__a31o_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3196_ net127 _0118_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2147_ _0611_ _0743_ _0701_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__o21ai_1
XFILLER_66_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2078_ net40 po_0._1_\[14\] VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and2_1
XFILLER_14_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_68 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3050_ _1332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
X_2001_ _0611_ _0603_ _0612_ _0609_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__o211ai_1
XFILLER_67_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2903_ po_0.regf_0.rf\[3\]\[8\] _0803_ _1251_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__mux2_1
X_2834_ _1216_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
X_2765_ _1163_ _1165_ _1168_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a21oi_1
X_1716_ po_0.regf_0.rf\[12\]\[9\] po_0.regf_0.rf\[13\]\[9\] po_0.regf_0.rf\[14\]\[9\]
+ po_0.regf_0.rf\[15\]\[9\] _1432_ _1433_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__mux4_1
X_2696_ _1107_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_1647_ _1437_ _1442_ _1444_ _1449_ VGND VGND VPWR VPWR po_0.regf_0._5_\[1\] sky130_fd_sc_hd__o22a_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3317_ net140 _0235_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_1578_ net80 net98 net99 _1387_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__or4bb_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3248_ net127 _0170_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ net146 _0101_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_487 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2550_ po_0.regf_0.rf\[13\]\[11\] _0984_ _1021_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__mux2_1
X_2481_ _0847_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__clkbuf_2
X_3102_ po_0.regf_0._5_\[12\] net91 VGND VGND VPWR VPWR po_0._1_\[12\] sky130_fd_sc_hd__dlxtp_1
XFILLER_55_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3033_ _1378_ _1392_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nor2_2
XFILLER_23_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2817_ _1207_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
X_2748_ net70 po_0.muxf_0.rf_w_data\[3\] VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__or2_1
X_2679_ uc_0._03_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__buf_4
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1981_ _0591_ po_0._1_\[1\] VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nand2_1
XFILLER_13_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2602_ _1056_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2533_ po_0.regf_0.rf\[13\]\[3\] _0967_ _1014_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__mux2_1
X_2464_ po_0.regf_0.rf\[15\]\[7\] _0976_ _0974_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__mux2_1
X_2395_ po_0.regf_0.rf\[9\]\[13\] _0848_ _0918_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__mux2_1
XFILLER_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3016_ _1313_ _0708_ _1304_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__mux2_1
XFILLER_24_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout131 net132 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout120 net124 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout142 net144 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_2
Xfanout153 net156 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout164 net166 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_2
Xfanout186 net187 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout175 net186 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_88 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_32 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2180_ net45 po_0._1_\[4\] po_0._1_\[5\] net46 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__a22o_1
XFILLER_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1964_ po_0.muxf_0.rf_w_data\[7\] VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__buf_2
XFILLER_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1895_ po_0.regf_0.rf\[0\]\[9\] po_0.regf_0.rf\[1\]\[9\] po_0.regf_0.rf\[2\]\[9\]
+ po_0.regf_0.rf\[3\]\[9\] _0474_ _0475_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__mux4_1
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2516_ _1008_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
X_2447_ _0738_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__clkbuf_2
X_2378_ po_0.regf_0.rf\[9\]\[5\] _0770_ _0919_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
XFILLER_56_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1680_ po_0.regf_0.rf\[12\]\[5\] po_0.regf_0.rf\[13\]\[5\] po_0.regf_0.rf\[14\]\[5\]
+ po_0.regf_0.rf\[15\]\[5\] _1432_ _1433_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__mux4_1
XFILLER_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3350_ net142 _0268_ VGND VGND VPWR VPWR po_0.regf_0.rf\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2301_ _0882_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3281_ net157 _0203_ VGND VGND VPWR VPWR uc_0._20_\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2232_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__clkbuf_2
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2163_ _0573_ _0693_ _0696_ net11 VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__a22o_1
XFILLER_38_368 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2094_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__buf_2
XFILLER_53_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2996_ uc_0.bc_0._54_\[1\] _1383_ uc_0.bc_0._54_\[2\] _1386_ VGND VGND VPWR VPWR
+ _1303_ sky130_fd_sc_hd__nand4_1
X_1947_ _0566_ _0484_ _0429_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a21o_1
X_1878_ po_0.regf_0.rf\[12\]\[7\] po_0.regf_0.rf\[13\]\[7\] po_0.regf_0.rf\[14\]\[7\]
+ po_0.regf_0.rf\[15\]\[7\] _0478_ _0479_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__mux4_1
XFILLER_29_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_224 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_31 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_198 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2850_ _1224_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__buf_2
X_1801_ _0432_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__and2b_1
X_2781_ _1180_ _1176_ _1178_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__o21ai_1
X_1732_ po_0.regf_0.rf\[12\]\[11\] po_0.regf_0.rf\[13\]\[11\] po_0.regf_0.rf\[14\]\[11\]
+ po_0.regf_0.rf\[15\]\[11\] _1446_ _1447_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__mux4_1
X_1663_ _0007_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__clkbuf_2
X_3402_ net157 _0320_ VGND VGND VPWR VPWR po_0.regf_0.w_addr\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1594_ po_0.regf_0.rp_addr\[1\] uc_0._20_\[9\] _1399_ VGND VGND VPWR VPWR _1401_
+ sky130_fd_sc_hd__mux2_1
X_3333_ net128 _0251_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3264_ net127 _0186_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2215_ _0639_ _0800_ _0645_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__a21oi_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3195_ net146 _0117_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2146_ _0729_ _0730_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__o21ai_1
X_2077_ _0674_ _0678_ _0679_ VGND VGND VPWR VPWR po_0.alu_0._10_\[13\] sky130_fd_sc_hd__nor3_1
X_2979_ _0830_ po_0.regf_0.rf\[0\]\[11\] _1289_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__mux2_1
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2000_ _0607_ _0608_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nor2_1
XFILLER_48_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2902_ _1253_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2833_ po_0.regf_0.rf\[4\]\[8\] _0803_ _1213_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__mux2_1
XFILLER_31_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2764_ _1163_ _1165_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__o21bai_1
X_1715_ _1474_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__and2b_1
X_2695_ net79 net20 _1098_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
X_1646_ _1445_ _1448_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__and2b_1
X_1577_ uc_0.bc_0._55_\[2\] uc_0.bc_0._55_\[3\] uc_0.bc_0._55_\[0\] uc_0.bc_0._55_\[1\]
+ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__and4bb_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3316_ net141 _0234_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3247_ net106 _0169_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3178_ net116 _0100_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_81_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2129_ _1340_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__buf_2
XFILLER_66_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_116 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2480_ _0987_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3101_ po_0.regf_0._5_\[11\] net91 VGND VGND VPWR VPWR po_0._1_\[11\] sky130_fd_sc_hd__dlxtp_1
X_3032_ _1302_ uc_0.bc_0._54_\[0\] net59 _1204_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_63_241 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2816_ po_0.regf_0.rf\[4\]\[0\] _0705_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__mux2_1
XFILLER_11_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2747_ _1123_ po_0.muxf_0.rf_w_data\[3\] VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__nand2_1
X_2678_ _1097_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
X_1629_ _1412_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__buf_4
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_105 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1980_ _1363_ po_0._1_\[0\] VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__or2b_1
XFILLER_13_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2601_ po_0.regf_0.rf\[11\]\[1\] _0963_ _1054_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__mux2_1
X_2532_ _1017_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
X_2463_ _0790_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__clkbuf_2
X_2394_ _0933_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
X_3015_ _1091_ uc_0._20_\[8\] _1397_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__mux2_1
XFILLER_36_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
Xfanout121 net124 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_1
XFILLER_59_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_1
Xfanout132 net145 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_1
Xfanout143 net144 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
Xfanout154 net156 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_2
Xfanout187 net33 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_2
Xfanout176 net178 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_74_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1963_ _0579_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
X_1894_ _0519_ _0484_ _0416_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a21o_1
X_2515_ po_0.regf_0.rf\[14\]\[11\] _0984_ _1002_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__mux2_1
X_2446_ _0964_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_2377_ _0924_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2300_ po_0.regf_0.rf\[5\]\[2\] _0739_ _0879_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
X_3280_ net157 _0202_ VGND VGND VPWR VPWR uc_0._20_\[10\] sky130_fd_sc_hd__dfxtp_1
X_2231_ net2 _0793_ _0820_ _0721_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__a22o_2
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2162_ _0727_ po_0.alu_0._11_\[4\] _0728_ net85 _0757_ VGND VGND VPWR VPWR _0758_
+ sky130_fd_sc_hd__a221o_1
XFILLER_65_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2093_ po_0.muxf_0.s0 po_0.muxf_0.s1 VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__and2b_1
XFILLER_46_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2995_ _1394_ net34 _1378_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__or3_2
X_1946_ po_0.regf_0.rf\[12\]\[15\] po_0.regf_0.rf\[13\]\[15\] po_0.regf_0.rf\[14\]\[15\]
+ po_0.regf_0.rf\[15\]\[15\] _0450_ _0451_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__mux4_1
X_1877_ _0473_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and2b_1
X_2429_ _0953_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1800_ po_0.regf_0.rf\[8\]\[0\] po_0.regf_0.rf\[9\]\[0\] po_0.regf_0.rf\[10\]\[0\]
+ po_0.regf_0.rf\[11\]\[0\] _0433_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__mux4_1
X_2780_ _1176_ _1180_ _1181_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__o21a_1
X_1731_ _0365_ _0367_ _0369_ _0371_ VGND VGND VPWR VPWR po_0.regf_0._5_\[10\] sky130_fd_sc_hd__o22a_1
X_1662_ po_0.regf_0.rf\[4\]\[3\] po_0.regf_0.rf\[5\]\[3\] po_0.regf_0.rf\[6\]\[3\]
+ po_0.regf_0.rf\[7\]\[3\] _1425_ _1426_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__mux4_1
X_3401_ net157 _0319_ VGND VGND VPWR VPWR po_0.regf_0.w_addr\[1\] sky130_fd_sc_hd__dfxtp_1
X_3332_ net107 _0250_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_1593_ _1400_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3263_ net106 _0185_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_280 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2214_ _0805_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_3194_ net116 _0116_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2145_ net87 po_0._1_\[2\] VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__nand2_1
XFILLER_38_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2076_ po_0._1_\[12\] _0672_ _0666_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__and3b_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2978_ _1294_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
X_1929_ po_0.regf_0.rf\[8\]\[13\] po_0.regf_0.rf\[9\]\[13\] po_0.regf_0.rf\[10\]\[13\]
+ po_0.regf_0.rf\[11\]\[13\] _0450_ _0451_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__mux4_1
XFILLER_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2901_ po_0.regf_0.rf\[3\]\[7\] _0790_ _1251_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__mux2_1
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2832_ _1215_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2763_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__clkbuf_2
X_1714_ po_0.regf_0.rf\[8\]\[9\] po_0.regf_0.rf\[9\]\[9\] po_0.regf_0.rf\[10\]\[9\]
+ po_0.regf_0.rf\[11\]\[9\] _1475_ _1476_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__mux4_1
X_2694_ _1106_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1645_ po_0.regf_0.rf\[8\]\[1\] po_0.regf_0.rf\[9\]\[1\] po_0.regf_0.rf\[10\]\[1\]
+ po_0.regf_0.rf\[11\]\[1\] _1446_ _1447_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__mux4_1
X_1576_ _1377_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__clkbuf_2
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3315_ net136 _0233_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3246_ net134 _0168_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3177_ net149 _0099_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2128_ _0726_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_54_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2059_ _0648_ _0657_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__or3_1
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput80 net80 VGND VGND VPWR VPWR leds[1] sky130_fd_sc_hd__buf_2
X_3100_ po_0.regf_0._5_\[10\] net91 VGND VGND VPWR VPWR po_0._1_\[10\] sky130_fd_sc_hd__dlxtp_1
X_3031_ _1200_ uc_0.bc_0._54_\[0\] uc_0.bc_0._54_\[2\] _1203_ net60 VGND VGND VPWR
+ VPWR _0324_ sky130_fd_sc_hd__a32o_1
XFILLER_36_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2815_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__buf_2
XFILLER_11_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2746_ _1141_ _1145_ _1144_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__a21boi_1
X_2677_ _0573_ net27 _1092_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__mux2_1
X_1628_ _1411_ _1419_ _1424_ _1431_ VGND VGND VPWR VPWR po_0.regf_0._5_\[0\] sky130_fd_sc_hd__o22a_1
X_1559_ _1363_ _1370_ net86 net87 VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__nor4_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3229_ net127 _0151_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_481 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2600_ _1055_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
X_2531_ po_0.regf_0.rf\[13\]\[2\] _0965_ _1014_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__mux2_1
XFILLER_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2462_ _0975_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2393_ po_0.regf_0.rf\[9\]\[12\] _0840_ _0918_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__mux2_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3014_ _1312_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2729_ net97 po_0.muxf_0.rf_w_data\[0\] _1135_ _1133_ VGND VGND VPWR VPWR _1136_
+ sky130_fd_sc_hd__a2bb2o_1
XFILLER_78_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout111 net112 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
Xfanout100 net102 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout122 net124 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout133 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout144 net145 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout155 net156 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_1
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_1
XFILLER_59_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout177 net178 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_256 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_124 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1962_ _0578_ po_0.regf_0.rq_addr\[2\] _0574_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__mux2_1
X_1893_ po_0.regf_0.rf\[4\]\[9\] po_0.regf_0.rf\[5\]\[9\] po_0.regf_0.rf\[6\]\[9\]
+ po_0.regf_0.rf\[7\]\[9\] _0410_ _0412_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__mux4_1
XFILLER_5_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2514_ _1007_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
X_2445_ po_0.regf_0.rf\[15\]\[1\] _0963_ _0961_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__mux2_1
X_2376_ po_0.regf_0.rf\[9\]\[4\] _0761_ _0919_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__mux2_1
XFILLER_68_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2230_ _0732_ _0816_ _0818_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__o31ai_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2161_ _1339_ _0755_ _0756_ _1336_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__and4bb_1
X_2092_ _0690_ _0692_ VGND VGND VPWR VPWR po_0.alu_0._10_\[15\] sky130_fd_sc_hd__nor2_1
XFILLER_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2994_ net90 _1204_ _1399_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__a21o_1
XFILLER_9_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1945_ _0560_ _0562_ _0441_ _0565_ VGND VGND VPWR VPWR po_0.regf_0._3_\[14\] sky130_fd_sc_hd__o22a_1
X_1876_ po_0.regf_0.rf\[8\]\[7\] po_0.regf_0.rf\[9\]\[7\] po_0.regf_0.rf\[10\]\[7\]
+ po_0.regf_0.rf\[11\]\[7\] _0474_ _0475_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux4_1
X_2428_ po_0.regf_0.rf\[1\]\[11\] _0830_ _0947_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__mux2_1
XFILLER_84_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2359_ po_0.regf_0.rf\[6\]\[13\] _0848_ _0898_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__mux2_1
XFILLER_56_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1730_ _1445_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__and2b_1
X_1661_ _1420_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__and2b_1
X_3400_ net157 _0318_ VGND VGND VPWR VPWR po_0.regf_0.w_addr\[0\] sky130_fd_sc_hd__dfxtp_1
X_3331_ net138 _0249_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_1592_ po_0.regf_0.rp_addr\[0\] uc_0._20_\[8\] _1399_ VGND VGND VPWR VPWR _1400_
+ sky130_fd_sc_hd__mux2_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3262_ net134 _0184_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2213_ po_0.regf_0.rf\[7\]\[8\] _0804_ _0781_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__mux2_1
XFILLER_38_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3193_ net149 _0115_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2144_ po_0.muxf_0.rf_w_data\[3\] VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__buf_2
X_2075_ _0675_ _0676_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2977_ _0822_ po_0.regf_0.rf\[0\]\[10\] _1289_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__mux2_1
X_1928_ _0544_ _0546_ _0548_ _0550_ VGND VGND VPWR VPWR po_0.regf_0._3_\[12\] sky130_fd_sc_hd__o22a_1
X_1859_ po_0.regf_0.rf\[4\]\[5\] po_0.regf_0.rf\[5\]\[5\] po_0.regf_0.rf\[6\]\[5\]
+ po_0.regf_0.rf\[7\]\[5\] _0410_ _0412_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__mux4_1
XFILLER_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2900_ _1252_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XFILLER_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_107 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2831_ po_0.regf_0.rf\[4\]\[7\] _0790_ _1213_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__mux2_1
X_2762_ uc_0._00_ uc_0._02_ _1126_ uc_0._01_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__or4bb_1
XFILLER_77_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1713_ _0350_ _0352_ _1430_ _0355_ VGND VGND VPWR VPWR po_0.regf_0._5_\[8\] sky130_fd_sc_hd__o22a_1
X_2693_ uc_0._20_\[11\] net19 _1098_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__mux2_1
X_1644_ _1414_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__clkbuf_4
X_1575_ _1385_ VGND VGND VPWR VPWR uc_0.bc_0._54_\[0\] sky130_fd_sc_hd__clkbuf_2
X_3314_ net131 _0232_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3245_ net126 _0167_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3176_ net149 _0098_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2127_ po_0.regf_0.rf\[7\]\[1\] _0725_ _0713_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__mux2_1
XFILLER_54_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_254 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2058_ _0646_ _0651_ _0652_ _0649_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__o211a_1
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput70 net70 VGND VGND VPWR VPWR I_addr[3] sky130_fd_sc_hd__buf_2
Xoutput81 net99 VGND VGND VPWR VPWR leds[2] sky130_fd_sc_hd__clkbuf_4
X_3030_ uc_0.bc_0._54_\[0\] _1302_ _1322_ _0574_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__o211a_1
XFILLER_48_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2814_ _0707_ _0875_ _1032_ _0877_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__and4b_4
X_2745_ _1149_ _1111_ _1125_ _1129_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__a31o_1
XFILLER_8_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2676_ _1096_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
X_1627_ _1427_ _1429_ _1430_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__a21o_1
X_1558_ net42 VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__clkbuf_2
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3228_ net133 _0150_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3159_ net174 _0081_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2530_ _1016_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
X_2461_ po_0.regf_0.rf\[15\]\[6\] _0973_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__mux2_1
X_2392_ _0932_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3013_ po_0.regf_0.rp_addr\[3\] uc_0._20_\[11\] _1398_ VGND VGND VPWR VPWR _1312_
+ sky130_fd_sc_hd__mux2_1
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2728_ net96 po_0.muxf_0.rf_w_data\[1\] VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__or2_1
X_2659_ po_0.regf_0.rf\[10\]\[12\] _0986_ _1072_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__mux2_1
Xfanout112 net125 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout101 net102 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout134 net138 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_2
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_1
Xfanout145 net187 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout156 net167 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_2
Xfanout167 net186 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_2
Xfanout178 net185 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_74_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1961_ po_0.muxf_0.rf_w_data\[6\] VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__clkbuf_2
X_1892_ _0513_ _0515_ _0430_ _0518_ VGND VGND VPWR VPWR po_0.regf_0._3_\[8\] sky130_fd_sc_hd__o22a_1
XFILLER_41_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2513_ po_0.regf_0.rf\[14\]\[10\] _0982_ _1002_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__mux2_1
X_2444_ _0724_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__clkbuf_2
X_2375_ _0923_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2160_ _0601_ _0731_ _0611_ _0612_ _0753_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a311o_1
X_2091_ _0686_ _0687_ _0688_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2993_ net94 _1204_ _0574_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a21bo_1
X_1944_ _0563_ _0564_ _0457_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__mux2_1
XFILLER_14_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1875_ _0498_ _0500_ _0441_ _0503_ VGND VGND VPWR VPWR po_0.regf_0._3_\[6\] sky130_fd_sc_hd__o22a_1
X_2427_ _0952_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2358_ _0913_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2289_ _0873_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_29_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1660_ po_0.regf_0.rf\[0\]\[3\] po_0.regf_0.rf\[1\]\[3\] po_0.regf_0.rf\[2\]\[3\]
+ po_0.regf_0.rf\[3\]\[3\] _1421_ _1422_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__mux4_1
XFILLER_7_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1591_ _1398_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__clkbuf_2
X_3330_ net128 _0248_ VGND VGND VPWR VPWR po_0.regf_0.rf\[8\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3261_ net129 _0183_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2212_ _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__clkbuf_2
XFILLER_22_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3192_ net149 _0114_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2143_ _0740_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2074_ _0669_ _0672_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__nand2_1
XFILLER_53_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2976_ _1293_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_1927_ _0415_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__and2b_1
X_1858_ _0477_ _0483_ _0486_ _0488_ VGND VGND VPWR VPWR po_0.regf_0._3_\[4\] sky130_fd_sc_hd__o22a_1
X_1789_ _0418_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__and2b_1
XFILLER_39_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_385 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2830_ _1214_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2761_ _1151_ _1164_ _1154_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__o21a_1
X_1712_ _0353_ _0354_ _1474_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__mux2_1
XFILLER_61_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2692_ _1105_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1643_ _1412_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__buf_4
XANTENNA_1 _0722_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1574_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3313_ net136 _0231_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3244_ net133 _0166_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3175_ net116 _0097_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2126_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__clkbuf_2
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2057_ net37 VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__inv_2
XFILLER_54_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2959_ _1284_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
XFILLER_45_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput60 net60 VGND VGND VPWR VPWR D_wr sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR I_addr[4] sky130_fd_sc_hd__buf_2
Xoutput82 net98 VGND VGND VPWR VPWR leds[3] sky130_fd_sc_hd__buf_2
XFILLER_0_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2813_ net34 _1112_ _1204_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__o21a_1
XFILLER_31_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2744_ _1124_ _1127_ net61 _1123_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__a31o_1
XFILLER_8_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2675_ _0741_ net26 _1092_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__mux2_1
X_1626_ _0007_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__buf_2
X_1557_ _1368_ uc_0.bc_0._55_\[1\] uc_0.bc_0._55_\[0\] VGND VGND VPWR VPWR _1369_
+ sky130_fd_sc_hd__and3_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3227_ net146 _0149_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3158_ net171 _0080_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2109_ po_0.regf_0.w_addr\[1\] VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__clkbuf_2
X_3089_ net115 _0047_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2460_ _0960_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__buf_2
X_2391_ po_0.regf_0.rf\[9\]\[11\] _0830_ _0926_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__mux2_1
XFILLER_83_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3012_ _1311_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_450 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2727_ net97 _1091_ _1132_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__or4b_1
X_2658_ _1086_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_2589_ _1048_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
Xfanout102 net112 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout113 net115 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlymetal6s2s_1
X_1609_ _1412_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__clkbuf_4
Xfanout135 net137 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_2
Xfanout124 net125 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout179 net180 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout168 net170 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_74_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_222 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1960_ _0577_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
X_1891_ _0516_ _0517_ _0448_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__mux2_1
X_2512_ _1006_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2443_ _0962_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_2374_ po_0.regf_0.rf\[9\]\[3\] _0749_ _0919_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux2_1
XFILLER_83_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2090_ _0680_ _0681_ _0684_ _0678_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2992_ _1338_ _1300_ _1301_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a21bo_1
X_1943_ po_0.regf_0.rf\[4\]\[14\] po_0.regf_0.rf\[5\]\[14\] po_0.regf_0.rf\[6\]\[14\]
+ po_0.regf_0.rf\[7\]\[14\] _0445_ _0446_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__mux4_1
XFILLER_9_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1874_ _0501_ _0502_ _0448_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__mux2_1
X_2426_ po_0.regf_0.rf\[1\]\[10\] _0822_ _0947_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__mux2_1
X_2357_ po_0.regf_0.rf\[6\]\[12\] _0840_ _0898_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__mux2_1
X_2288_ po_0.regf_0.rf\[7\]\[15\] _0872_ _0712_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__mux2_1
XFILLER_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1590_ uc_0.bc_0._54_\[1\] _1393_ _1397_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__o21ai_4
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3260_ net133 _0182_ VGND VGND VPWR VPWR po_0.regf_0.rf\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2211_ net15 _0793_ _0802_ _0721_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__a22o_2
X_3191_ net116 _0113_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2142_ po_0.regf_0.rf\[7\]\[2\] _0739_ _0713_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__mux2_1
XFILLER_66_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2073_ _0664_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__inv_2
XFILLER_38_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2975_ _0812_ po_0.regf_0.rf\[0\]\[9\] _1289_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__mux2_1
X_1926_ po_0.regf_0.rf\[8\]\[12\] po_0.regf_0.rf\[9\]\[12\] po_0.regf_0.rf\[10\]\[12\]
+ po_0.regf_0.rf\[11\]\[12\] _0433_ _0434_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__mux4_1
X_1857_ _0487_ _0458_ _0441_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a21o_1
X_1788_ po_0.regf_0.rf\[0\]\[0\] po_0.regf_0.rf\[1\]\[0\] po_0.regf_0.rf\[2\]\[0\]
+ po_0.regf_0.rf\[3\]\[0\] _0420_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__mux4_1
XFILLER_39_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3389_ net173 _0307_ VGND VGND VPWR VPWR po_0.regf_0.rq_rd sky130_fd_sc_hd__dfxtp_1
X_2409_ po_0.regf_0.rf\[1\]\[2\] _0739_ _0940_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__mux2_1
XFILLER_76_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2760_ net69 po_0.muxf_0.rf_w_data\[2\] _1152_ _1153_ VGND VGND VPWR VPWR _1164_
+ sky130_fd_sc_hd__and4bb_1
X_1711_ po_0.regf_0.rf\[4\]\[8\] po_0.regf_0.rf\[5\]\[8\] po_0.regf_0.rf\[6\]\[8\]
+ po_0.regf_0.rf\[7\]\[8\] _0338_ _0339_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__mux4_1
X_2691_ uc_0._20_\[10\] net18 _1099_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__mux2_1
X_1642_ _1428_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__buf_2
XANTENNA_2 _0741_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1573_ _1377_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__and2_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3312_ net156 _0230_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3243_ net147 _0165_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3174_ net146 _0096_ VGND VGND VPWR VPWR po_0.regf_0.rf\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2125_ _0720_ _0721_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a21o_2
XFILLER_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2056_ _0659_ _0651_ _0650_ _0657_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nor4_1
XFILLER_54_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2958_ _0725_ po_0.regf_0.rf\[0\]\[1\] _1282_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__mux2_1
X_1909_ _0533_ _0458_ _0461_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a21o_1
X_2889_ _1246_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_120 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput50 net50 VGND VGND VPWR VPWR D_W_data[9] sky130_fd_sc_hd__clkbuf_4
Xoutput61 net97 VGND VGND VPWR VPWR I_addr[0] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR I_addr[5] sky130_fd_sc_hd__buf_2
XFILLER_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2812_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__buf_2
X_2743_ _1124_ _1128_ _1140_ _1148_ _1126_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o221a_1
X_2674_ _1095_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
X_1625_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__clkbuf_2
X_1556_ net98 net99 net80 VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__or3b_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3226_ net116 _0148_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3157_ net101 _0079_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2108_ po_0.regf_0.w_addr\[0\] VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__clkbuf_2
X_3088_ net105 _0046_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_2039_ po_0._1_\[8\] net84 VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__or2b_1
XFILLER_50_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_418 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2390_ _0931_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3011_ po_0.regf_0.rp_addr\[2\] uc_0._20_\[10\] _1398_ VGND VGND VPWR VPWR _1311_
+ sky130_fd_sc_hd__mux2_1
XFILLER_76_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2726_ net96 _0722_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nand2_1
X_2657_ po_0.regf_0.rf\[10\]\[11\] _0984_ _1080_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__mux2_1
X_1608_ _0004_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2588_ po_0.regf_0.rf\[12\]\[12\] _0986_ _1033_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__mux2_1
Xfanout103 net112 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout136 net138 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_2
Xfanout114 net115 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
X_1539_ _1357_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__clkbuf_1
Xfanout125 net187 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout147 net152 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout169 net170 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_1
Xfanout158 net159 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlymetal6s2s_1
X_3209_ net149 _0131_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_384 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_248 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1890_ po_0.regf_0.rf\[12\]\[8\] po_0.regf_0.rf\[13\]\[8\] po_0.regf_0.rf\[14\]\[8\]
+ po_0.regf_0.rf\[15\]\[8\] _0445_ _0446_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__mux4_1
X_2511_ po_0.regf_0.rf\[14\]\[9\] _0980_ _1002_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__mux2_1
X_2442_ po_0.regf_0.rf\[15\]\[0\] _0958_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__mux2_1
X_2373_ _0922_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2709_ _1091_ uc_0._01_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__or2b_1
XFILLER_58_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2991_ net34 _1385_ _1394_ _1200_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__or4_1
X_1942_ po_0.regf_0.rf\[0\]\[14\] po_0.regf_0.rf\[1\]\[14\] po_0.regf_0.rf\[2\]\[14\]
+ po_0.regf_0.rf\[3\]\[14\] _0445_ _0446_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__mux4_1
X_1873_ po_0.regf_0.rf\[4\]\[6\] po_0.regf_0.rf\[5\]\[6\] po_0.regf_0.rf\[6\]\[6\]
+ po_0.regf_0.rf\[7\]\[6\] _0445_ _0446_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__mux4_1
X_2425_ _0951_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2356_ _0912_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_2287_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__clkbuf_2
XFILLER_37_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_148 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2210_ _0799_ _0800_ _0716_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__a31o_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3190_ net146 _0112_ VGND VGND VPWR VPWR po_0.regf_0.rf\[14\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2141_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__clkbuf_2
XFILLER_81_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2072_ _0643_ _0660_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nand2_1
XFILLER_66_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2974_ _1292_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
X_1925_ _0547_ _0481_ _0482_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21o_1
X_1856_ po_0.regf_0.rf\[4\]\[4\] po_0.regf_0.rf\[5\]\[4\] po_0.regf_0.rf\[6\]\[4\]
+ po_0.regf_0.rf\[7\]\[4\] _0454_ _0455_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux4_1
X_1787_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__buf_2
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2408_ _0942_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
X_3388_ net174 _0306_ VGND VGND VPWR VPWR po_0.alu_0.s0 sky130_fd_sc_hd__dfxtp_1
X_2339_ _0903_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
XFILLER_29_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1710_ po_0.regf_0.rf\[0\]\[8\] po_0.regf_0.rf\[1\]\[8\] po_0.regf_0.rf\[2\]\[8\]
+ po_0.regf_0.rf\[3\]\[8\] _1475_ _1476_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__mux4_1
X_2690_ _1104_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_3 _0858_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1641_ _1443_ _1417_ _1436_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__a21bo_1
XFILLER_6_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3311_ net170 _0229_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1572_ uc_0.bc_0._55_\[2\] uc_0.bc_0._55_\[3\] _1382_ _1367_ VGND VGND VPWR VPWR
+ _1383_ sky130_fd_sc_hd__o31a_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3242_ net147 _0164_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3173_ net109 _0095_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2124_ _0722_ _0694_ _0697_ net8 VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__a22o_1
XFILLER_81_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2055_ _0639_ _0640_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__and2_1
XFILLER_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2957_ _1283_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
X_1908_ po_0.regf_0.rf\[4\]\[10\] po_0.regf_0.rf\[5\]\[10\] po_0.regf_0.rf\[6\]\[10\]
+ po_0.regf_0.rf\[7\]\[10\] _0454_ _0455_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux4_1
X_2888_ po_0.regf_0.rf\[3\]\[1\] _0724_ _1244_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__mux2_1
X_1839_ _0457_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and2b_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_243 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput51 net51 VGND VGND VPWR VPWR D_addr[0] sky130_fd_sc_hd__buf_2
Xoutput40 net40 VGND VGND VPWR VPWR D_W_data[14] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR I_addr[6] sky130_fd_sc_hd__clkbuf_4
Xoutput62 net62 VGND VGND VPWR VPWR I_addr[10] sky130_fd_sc_hd__buf_2
XFILLER_36_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2811_ _1201_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__nor2_1
XFILLER_75_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2742_ _1141_ _1144_ _1145_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a31oi_1
X_2673_ _0736_ net25 _1092_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__mux2_1
X_1624_ _0006_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__buf_2
X_1555_ net34 VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__inv_2
X_3225_ net149 _0147_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3156_ net105 _0078_ VGND VGND VPWR VPWR po_0.regf_0.rf\[9\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3087_ net122 _0045_ VGND VGND VPWR VPWR po_0.regf_0.rf\[5\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_2107_ po_0.regf_0.w_addr\[3\] VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2038_ _0644_ po_0._1_\[9\] VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__xnor2_2
XFILLER_77_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_474 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3010_ _1310_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2725_ net96 _0722_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nor2_1
X_2656_ _1085_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
X_1607_ _1405_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__and2b_1
Xfanout104 net108 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlymetal6s2s_1
X_2587_ _1047_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
Xfanout126 net129 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_2
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_1
Xfanout115 net119 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_2
X_1538_ _1349_ _1351_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__or2b_1
Xfanout148 net152 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_1
Xfanout159 net167 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__clkbuf_1
X_3208_ net151 _0130_ VGND VGND VPWR VPWR po_0.regf_0.rf\[13\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3139_ net160 _0009_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__dfxtp_1
XFILLER_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2510_ _1005_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
X_2441_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__buf_2
XFILLER_38_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2372_ po_0.regf_0.rf\[9\]\[2\] _0739_ _0919_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__mux2_1
XFILLER_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2708_ _1111_ _1114_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__o21ba_1
X_2639_ _1076_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_363 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2990_ _1395_ _1342_ _1300_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__a21bo_1
XFILLER_14_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1941_ _0473_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__and2b_1
X_1872_ po_0.regf_0.rf\[0\]\[6\] po_0.regf_0.rf\[1\]\[6\] po_0.regf_0.rf\[2\]\[6\]
+ po_0.regf_0.rf\[3\]\[6\] _0442_ _0443_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__mux4_1
XFILLER_9_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2424_ po_0.regf_0.rf\[1\]\[9\] _0812_ _0947_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__mux2_1
X_2355_ po_0.regf_0.rf\[6\]\[11\] _0830_ _0906_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__mux2_1
XFILLER_29_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2286_ _0862_ _0868_ _0869_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_322 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2140_ _0735_ _0721_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a21o_2
XFILLER_66_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2071_ _0665_ _0670_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o21a_1
XFILLER_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2973_ _0804_ po_0.regf_0.rf\[0\]\[8\] _1289_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__mux2_1
X_1924_ po_0.regf_0.rf\[12\]\[12\] po_0.regf_0.rf\[13\]\[12\] po_0.regf_0.rf\[14\]\[12\]
+ po_0.regf_0.rf\[15\]\[12\] _0478_ _0479_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__mux4_1
X_1855_ _0484_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__and2b_1
X_1786_ _0001_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__buf_2
X_2407_ po_0.regf_0.rf\[1\]\[1\] _0725_ _0940_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__mux2_1
X_3387_ net173 _0305_ VGND VGND VPWR VPWR po_0.alu_0.s1 sky130_fd_sc_hd__dfxtp_1
X_2338_ po_0.regf_0.rf\[6\]\[3\] _0749_ _0899_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__mux2_1
XFILLER_84_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2269_ _0680_ _0681_ _0853_ _0851_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o211ai_1
XFILLER_29_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_355 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1640_ po_0.regf_0.rf\[12\]\[1\] po_0.regf_0.rf\[13\]\[1\] po_0.regf_0.rf\[14\]\[1\]
+ po_0.regf_0.rf\[15\]\[1\] _1413_ _1415_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__mux4_1
X_1571_ _1380_ _1381_ uc_0.bc_0._55_\[1\] VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__a21boi_1
XANTENNA_4 _1091_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3310_ net155 _0228_ VGND VGND VPWR VPWR po_0.regf_0.rf\[4\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3241_ net150 _0163_ VGND VGND VPWR VPWR po_0.regf_0.rf\[11\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3172_ net109 _0094_ VGND VGND VPWR VPWR po_0.regf_0.rf\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2123_ po_0.muxf_0.rf_w_data\[1\] VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__buf_2
XFILLER_19_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2054_ _0657_ _0658_ VGND VGND VPWR VPWR po_0.alu_0._10_\[11\] sky130_fd_sc_hd__xnor2_1
XFILLER_22_325 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2956_ _0706_ po_0.regf_0.rf\[0\]\[0\] _1282_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__mux2_1
X_1907_ _0418_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__and2b_1
X_2887_ _1245_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_1838_ po_0.regf_0.rf\[0\]\[3\] po_0.regf_0.rf\[1\]\[3\] po_0.regf_0.rf\[2\]\[3\]
+ po_0.regf_0.rf\[3\]\[3\] _0419_ _0421_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__mux4_1
X_1769_ po_0.regf_0.rf\[0\]\[15\] po_0.regf_0.rf\[1\]\[15\] po_0.regf_0.rf\[2\]\[15\]
+ po_0.regf_0.rf\[3\]\[15\] _1439_ _1440_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux4_1
X_3439_ po_0.alu_0._10_\[14\] _1505_ VGND VGND VPWR VPWR po_0.alu_0._11_\[14\] sky130_fd_sc_hd__ebufn_1
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput52 net52 VGND VGND VPWR VPWR D_addr[1] sky130_fd_sc_hd__buf_2
Xoutput41 net41 VGND VGND VPWR VPWR D_W_data[15] sky130_fd_sc_hd__buf_2
Xoutput63 net63 VGND VGND VPWR VPWR I_addr[11] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR I_addr[7] sky130_fd_sc_hd__buf_2
XFILLER_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_163 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2810_ _1385_ _1390_ uc_0.bc_0._54_\[1\] _1392_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__and4b_1
X_2741_ _1136_ _1146_ _1112_ _1113_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__a211o_1
X_2672_ _1094_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1623_ po_0.regf_0.rf\[4\]\[0\] po_0.regf_0.rf\[5\]\[0\] po_0.regf_0.rf\[6\]\[0\]
+ po_0.regf_0.rf\[7\]\[0\] _1425_ _1426_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__mux4_1
X_1554_ _1366_ VGND VGND VPWR VPWR po_0.alu_0._10_\[0\] sky130_fd_sc_hd__clkbuf_1
X_3224_ net150 _0146_ VGND VGND VPWR VPWR po_0.regf_0.rf\[12\]\[2\] sky130_fd_sc_hd__dfxtp_1
.ends
