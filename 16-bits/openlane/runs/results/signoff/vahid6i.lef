VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO vahid6i
  CLASS BLOCK ;
  FOREIGN vahid6i ;
  ORIGIN 0.000 0.000 ;
  SIZE 0.005 BY 0.005 ;
END vahid6i
END LIBRARY

